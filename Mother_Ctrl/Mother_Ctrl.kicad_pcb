# Repository Tomoshibi-technology/RCJ-Japan2024-Circuit

## KiCad design Mother_Ctrl/Mother_Ctrl.kicad_pcb

Parts:
C1, C9, C11, C13, C14, C19, C31: 1uF; C_0402_1005Metric
C2, C4, C5, C6, C24, C25, C26, C27, C28, C29, C32, C33, C34, C35, C36, C37: 0.1uF; C_0402_1005Metric
C3, C10: 10uF; C_0805_2012Metric
C7: 22uF; C_0805_2012Metric
C8, C12: ADJ_ST; C_0603_1608Metric
C15, C16, C17, C18: 22pF; C_0603_1608Metric
C20, C21, C22, C23: 470uF; C_Elec_8x10.2
C30: 4.7uF; C_0603_1608Metric
D1, D2, D5, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D31, D32, D33, D34, D35, D36, D37, D38, D39: 1N5819WS; D_SOD-323_HandSoldering
D3, D25, D26: Yellow; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D4: MA10EB045; DO-221BC
D6, D7, D8, D22, D23: Red; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D9, D21: D_Zener; D_SOD-323_HandSoldering
D27, D28, D29, D30: Green; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
H4, H5: MountingHole_Pad; TestPoint_Pad_1.0x1.0mm
H7, H8, H11: MountingHole_Pad; TestPoint_Pad_1.5x1.5mm
J1: Conn_01x02_Male; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J2: Conn_01x02_Female; AMASS_XT30PW-F_1x02_P2.50mm_Horizontal
J3: USB_C_Receptacle_USB2.0; USB_C_Receptacle_G-Switch_GT-USB-7010ASV
J4: Conn_01x07_Female; PinSocket_1x07_P2.54mm_Horizontal
J5: Conn_01x10_Male; BoxHeader_2x05_P1.27mm_Vertical_SMD
J6: Conn_01x02_Male; Molex_SPOX_5268-02A_1x02_P2.50mm_Horizontal
J7, J8: Conn_01x03_Male; Molex_SPOX_5268-03A_1x03_P2.50mm_Horizontal
J9, J10, J11, J12: Conn_01x04_Male; Molex_SPOX_5268-04A_1x04_P2.50mm_Horizontal
J13, J14: Conn_01x05_Male; Molex_SPOX_5268-05A_1x05_P2.50mm_Horizontal
J15, J16, J17: Conn_01x12_Female; PinSocket_1x12_P2.54mm_Vertical
JP1, JP2: Jumper_2_Open; PinHeader_1x02_P2.54mm_Vertical
MD1: OKL-T/6-W12N-C; MURATA_OKL-T-6-W12N-C; MOUSER_PART_NUMBER 580-OKL-T/6-W12N-C
Q1, Q3, Q29: MTP4835I3; TO-252-2
Q2, Q23, Q24, Q25, Q26, Q27, Q28: BSS138; SOT-23
Q4, Q6, Q9, Q10, Q13, Q15, Q17, Q19, Q21: SSM3J332R; SOT-23W
Q5, Q7, Q8, Q11, Q12, Q14, Q16, Q18, Q20, Q22, Q30, Q31, Q32: S8050; SOT-23
R1, R4, R9, R12, R13, R14, R16, R20, R25, R27, R28, R30, R31, R32, R33, R34, R35, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R61, R65, R68, R69, R74, R75, R76, R77, R78, R79, R80, R81, R82, R83, R86, R87, R102, R103: 10k; R_0402_1005Metric
R2, R21, R29, R37, R60: 100k; R_0402_1005Metric
R3, R5, R64: PullUP?; R_0603_1608Metric
R6, R10: 5.1k; R_0402_1005Metric
R7: 33k; R_0603_1608Metric
R8: 10k; R_0603_1608Metric
R11, R15, R17, R18, R19, R22, R36, R62, R63, R66, R67, R70, R71, R72, R73: 1k; R_0402_1005Metric
R23: 330; R_0402_1005Metric
R24: 10; R_0402_1005Metric
R26: 1.2k; R_0402_1005Metric
R84, R85: PullUP; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R88, R89, R92: 7.5k; R_0603_1608Metric
R90, R91, R93: 20k; R_0402_1005Metric
R94, R95, R96, R97, R100, R101: 2.2k; R_0402_1005Metric
R98, R99: 120; R_0402_1005Metric
SW1: SW_SPDT; 3P_SPDT_5Pin_ToggleSwitch
SW2, SW3, SW6, SW7: SW_SPST; SW_Push_1P1T_NO_Vertical_Wuerth_434133025816
SW4: SW_DPDT_x2; SW_CuK_JS202011CQN_DPDT_Straight
SW5: SW_SPDT; 3P_SPDT_SlideSwitch
TP5: TestPoint; TestPoint_THTPad_D2.0mm_Drill1.0mm
U1: CH340E; MSOP-10_3x3mm_P0.5mm
U2: TWE-L-WX; MonoWireless_TWE-L-WX
U3: AZ1084CD-3.3; TO-252-2
U4: STM32F446RETx; LQFP-64_10x10mm_P0.5mm
U5: BNO055
U6, U7, U8: MAX3485; SOP-8_3.9x4.9mm_P1.27mm
Y1: 16MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm_HandSoldering
Y2: 32.768kHz; Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
+3.3V: C9.2, C23.1, C24.1, C25.1, C26.1, C28.1, C29.1, C31.1, C32.1, C33.1, C34.1, C35.1, D21.1 (K), D36.1 (K), D37.1 (K), D38.1 (K), D39.1 (K), J16.12, Q17.2 (S), Q18.2 (E), Q21.2 (S), Q22.2 (E), Q23.1 (G), Q24.1 (G), Q25.1 (G), Q26.1 (G), Q27.1 (G), Q30.2 (E), Q31.2 (E), Q32.2 (E), R3.1, R5.1, R59.2, R64.2, R73.2, R74.2, R75.2, R78.2, R80.2, R81.2, R84.1, R85.1, R94.1, R96.1, R100.1, SW5.2 (B), SW6.2 (B), U2.5 (VCC), U4.1 (VBAT), U4.13 (VDDA), U4.19 (VDD), U4.32 (VDD), U4.48 (VDD), U4.64 (VDD), U5.3 (VDD), U6.8 (VCC), U7.8 (VCC), U8.8 (VCC)
+5V: C13.1, C22.1, D9.1 (K), D20.1 (K), D31.2 (A), D32.2 (A), D33.2 (A), D34.2 (A), D35.2 (A), J7.2, J8.2, J15.10, J16.10, Q6.2 (S), Q7.2 (E), Q8.2 (E), Q9.3 (D), Q13.2 (S), Q14.2 (E), R27.2, R44.1, R71.2, U3.3 (VI)
/3.3VBUS: C6.1, J5.1, Q15.2 (S), R34.2
/3.3VSYS: C14.1, C19.1, D20.2 (A), Q19.2 (S), R35.1, R36.1, R58.2, R60.1, U3.2 (VO)
/3.3V_IND: Q15.3 (D), Q16.2 (E), Q17.3 (D), R45.2, R72.2
/5VBUS: C3.2, C4.1, J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS), Q4.2 (S), R12.2, U1.7 (VCC)
/5VSYS: C10.1, C11.1, D5.2 (A), MD1.4 (VOUT), MD1.5 (SENSE), Q10.2 (S), R14.1, R15.1, R21.2, R26.2, R29.1
/5V_IND: Q4.3 (D), Q5.2 (E), Q6.3 (D), R16.2, R70.2
/12VBAT: J1.2, J2.2, Q1.2 (D)
/S-S: C1.1, Q1.3 (S), Q3.3 (S), R1.1, R2.1, SW1.2 (B)
BOOT0: J15.4, R69.1, SW6.1 (A), U4.60 (BOOT0)
Conn_Detect: J16.7, R102.1, U4.8 (PC0)
DAC: J16.8, U4.20 (PA4)
DIP_SW0: D10.2 (A), D11.2 (A), J17.6
DIP_SW1: D12.2 (A), D13.2 (A), J17.7
DIP_SW2: D14.2 (A), D15.2 (A), J17.8
DIP_SW3: D16.2 (A), D17.2 (A), J17.9
DIP_SW4: D18.2 (A), D19.2 (A), J17.10
F446USBRX: SW4.6 (C), U1.9 (RXD)
F446USBTX: SW4.3 (C), U1.8 (TXD)
F446_DIP0: D10.1 (K), R47.1, U4.45 (PA12)
F446_DIP1: D12.1 (K), R49.1, U4.44 (PA11)
F446_DIP2: D14.1 (K), R51.1, U4.41 (PA8)
F446_DIP3: D16.1 (K), R53.1, U4.51 (PC10)
F446_DIP4: D18.1 (K), R55.1, U4.52 (PC11)
GND: C2.2, C3.1, C4.2, C5.2, C6.2, C7.2, C8.1, C9.1, C10.2, C12.1, C13.2, C14.2, C15.1, C16.1, C17.1, C18.1, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.1, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, D1.2 (A), D3.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.2 (A), D21.2 (A), D22.1 (K), D23.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), J1.1, J2.1, J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J3.S1 (SHIELD), J4.1, J5.4, J6.1, J7.1, J8.1, J9.1, J9.2, J10.1, J10.2, J11.1, J11.2, J12.1, J12.2, J13.1, J13.2, J13.3, J14.1, J14.2, J14.3, J15.9, J15.11, J15.12, J16.9, MD1.1 (ON/OFF), MD1.3 (GND), MD1.7 (GND), Q1.1 (G), Q2.2 (S), Q28.2 (S), R1.2, R6.1, R8.2, R9.2, R10.1, R12.1, R13.2, R15.2, R16.1, R20.1, R24.2, R25.1, R26.1, R27.1, R28.1, R30.2, R31.1, R32.1, R33.1, R34.1, R36.2, R37.2, R38.2, R39.2, R40.2, R41.2, R42.2, R43.2, R44.2, R45.1, R46.1, R47.2, R48.2, R49.2, R50.2, R51.2, R52.2, R53.2, R54.2, R55.2, R56.2, R57.1, R58.1, R59.1, R61.2, R65.1, R68.1, R69.2, R87.1, R90.2, R91.2, R93.2, R95.2, R97.2, R101.2, R102.2, R103.2, SW2.2 (B), SW3.2 (B), SW7.2 (B), TP5.1, U1.3 (GND), U2.20 (GND), U2.22 (ADC2/AI3), U2.23 (ADC1/AI1), U2.28 (GND), U2.30 (GND), U2.31 (GND), U2.32 (GND), U3.1 (GND), U4.12 (VSSA), U4.18 (VSS), U4.31 (VSS), U4.47 (VSS), U4.63 (VSS), U5.2 (GND), U6.5 (GND), U7.5 (GND), U8.5 (GND), Y1.2, Y1.4
Gyro_RST: U4.40 (PC9), U5.11 (~RESET)
HSE_IN: C15.2, U4.5 (PH0), Y1.1
HSE_OUT: C16.2, U4.6 (PH1), Y1.3
I2C1_SCL: J17.2, R85.2, U4.61 (PB8), U5.19 (COM1)
I2C1_SDA: J17.1, R84.2, U4.59 (PB7), U5.20 (COM0)
LED0: R62.2, U4.56 (PB4)
LED1: R63.2, U4.50 (PA15)
LEDTape0_H: J7.3, Q23.3 (D), R76.1
LEDTape0_L: Q23.2 (S), R74.1, U4.22 (PA6)
LEDTape1_H: J16.1, Q24.3 (D), R77.1
LEDTape1_L: Q24.2 (S), R75.1, U4.26 (PB0)
LEDTape2_H: J15.1, Q26.3 (D), R82.1
LEDTape2_L: Q26.2 (S), R80.1, U4.27 (PB1)
LEDTape3_H: J17.4, Q27.3 (D), R83.1
LEDTape3_L: Q27.2 (S), R81.1, U4.58 (PB6)
LSE_IN: C17.2, U4.3 (PC14), Y2.2
LSE_OUT: C18.2, U4.4 (PC15), Y2.1
MainRX1_F446WriteTX: SW4.2 (B), U4.43 (PA10)
MainRX2_ArmTX: U4.17 (PA3), U8.1 (RO)
MainRX3_RS485bTX: U4.25 (PC5), U7.1 (RO)
MainRX5_TweTX1: U2.14 (DIO14/SCL), U4.54 (PD2)
MainRX6_RS485aTX: U4.38 (PC7), U6.1 (RO)
MainTX1_F446WriteRX: SW4.5 (B), U4.42 (PA9)
MainTX2_ArmRX: R92.2, U4.16 (PA2), U8.4 (DI)
MainTX3_RS485bRX: R89.2, U4.29 (PB10), U7.4 (DI)
MainTX5_TweRX1: U2.17 (DIO15/SDA), U4.53 (PC12)
MainTX6_RS485aRX: R88.2, U4.37 (PC6), U6.4 (DI)
MonitorLED0: J16.5, R66.2, R103.1, U4.28 (PB2)
MonitorLED1: J15.6, R67.2, U4.21 (PA5)
NRST: C27.1, J5.6, J17.5, SW7.1 (A), U4.7 (NRST)
NeoPixel_H: J17.3, Q25.3 (D), R79.1
NeoPixel_L: Q25.2 (S), R78.1, U4.57 (PB5)
unnamed: C1.2, Q3.1 (G), R2.2, R4.1
unnamed: C5.1, U1.10 (V3)
unnamed: C8.2, H4.1, Q4.1 (G), R14.2
unnamed: C11.2, Q10.1 (G), R29.2, R30.1
unnamed: C12.2, H7.1, Q15.1 (G), R35.2
unnamed: C19.2, Q19.1 (G), R60.2, R61.1
unnamed: C30.2, U4.30 (VCAP_1)
unnamed: D3.2 (A), R11.1
unnamed: D6.2 (A), R17.1
unnamed: D7.2 (A), R18.1
unnamed: D8.2 (A), R19.1
unnamed: D22.2 (A), R62.1
unnamed: D23.2 (A), R63.1
unnamed: D25.2 (A), R66.1
unnamed: D26.2 (A), R67.1
unnamed: D27.2 (A), R70.1
unnamed: D28.2 (A), R71.1
unnamed: D29.2 (A), R72.1
unnamed: D30.2 (A), R73.1
unnamed: D31.1 (K), R76.2
unnamed: D32.1 (K), R77.2
unnamed: D33.1 (K), R79.2
unnamed: D34.1 (K), R82.2
unnamed: D35.1 (K), R83.2
unnamed: H5.1, Q6.1 (G), Q7.3 (C), R25.2
unnamed: H8.1, Q17.1 (G), Q18.3 (C), R57.2
unnamed: J3.A5 (CC1), R10.2
unnamed: J3.A6 (D+), J3.B6 (D+), U1.1 (UD+)
unnamed: J3.A7 (D-), J3.B7 (D-), U1.2 (UD-)
unnamed: J3.B5 (CC2), R6.2
unnamed: J6.2, Q9.2 (S), Q11.2 (E)
unnamed: JP1.2 (B), R98.1
unnamed: JP2.2 (B), R99.1
unnamed: MD1.6 (TRIM), R22.1
unnamed: MD1.10 (PGOOD), R21.1
unnamed: Q2.3 (D), R4.2
unnamed: Q5.1 (B), Q5.3 (C), Q7.1 (B), R20.2
unnamed: Q10.3 (D), Q12.2 (E), Q13.3 (D)
unnamed: Q8.1 (B), Q8.3 (C), Q11.1 (B), R28.2
unnamed: Q9.1 (G), Q11.3 (C), R31.2
unnamed: Q12.1 (B), Q12.3 (C), Q14.1 (B), R32.2
unnamed: Q13.1 (G), Q14.3 (C), R33.2
unnamed: Q16.1 (B), Q16.3 (C), Q18.1 (B), R46.2
unnamed: Q19.3 (D), Q20.2 (E), Q21.3 (D)
unnamed: Q20.1 (B), Q20.3 (C), Q22.1 (B), R65.2
unnamed: Q21.1 (G), Q22.3 (C), R68.2
unnamed: Q28.3 (D), Q29.1 (G), R86.1
unnamed: Q30.1 (B), R88.1
unnamed: Q30.3 (C), R90.1, U6.2 (~RE), U6.3 (DE)
unnamed: Q31.1 (B), R89.1
unnamed: Q31.3 (C), R91.1, U7.2 (~RE), U7.3 (DE)
unnamed: Q32.1 (B), R92.1
unnamed: Q32.3 (C), R93.1, U8.2 (~RE), U8.3 (DE)
unnamed: R11.2, U1.6 (TNOW)
unnamed: R22.2, R23.2
unnamed: R23.1, R24.1
unnamed: R64.1, U2.1 (DO0/PWM2)
unnamed: R100.2, R101.1, U8.7 (B)
PRG: J4.3, J17.11, R5.2, SW3.1 (A), U2.2 (DO1/PWM3)
RS485_Arm: J13.5, J14.5, U8.6 (A)
RS485a_A: J9.3, J10.3, JP1.1 (A), R94.2, U6.6 (A)
RS485a_B: J9.4, J10.4, R95.1, R98.2, U6.7 (B)
RS485b_A: J11.3, J12.3, JP2.1 (A), R96.2, U7.6 (A)
RS485b_B: J11.4, J12.4, R97.1, R99.2, U7.7 (B)
RST: C2.1, D2.2 (A), J4.5, J17.12, R3.2, SW2.1 (A), U2.21 (~RESET)
SET: J4.7, U2.13 (DIO12/DI1)
STLinkRX: J5.9, SW4.4 (A)
STLinkTX: J5.8, SW4.1 (A)
SWO: J5.7, U4.55 (PB3)
Sensor0: D36.2 (A), H11.1, J8.3, U4.11 (PC3)
Sensor1: D37.2 (A), J15.7, U4.9 (PC1)
Sensor2: D38.2 (A), J15.8, U4.10 (PC2)
Sensor3: D39.2 (A), J16.6, U4.23 (PA7)
Servo_SW: Q28.1 (G), R87.2, U4.15 (PA1)
Slide_SW0: R41.1, SW5.1 (A), U4.62 (PB9)
Slide_SW1: J15.2, R42.1, U4.36 (PB15)
Slide_SW2: J15.3, R43.1, U4.34 (PB13)
TCK: J5.3, U4.49 (PA14)
TMS: J5.5, U4.46 (PA13)
Tact_SW0: J16.3, R38.1, U4.35 (PB14)
Tact_SW1: J16.4, R39.1, U4.33 (PB12)
Tact_SW2: J16.2, R40.1, U4.39 (PC8)
TweRST_Sig: D2.1 (K), U4.2 (PC13)
TweWriteRX_TweTX0: J4.2, U2.8 (DIO6/TX)
TweWriteTX_TweRX0: J4.4, U2.9 (DIO7/RX)
Twe_DIP0: D11.1 (K), R48.1, U2.7 (DIO5/PWM1)
Twe_DIP1: D13.1 (K), R50.1, U2.11 (DIO9/DO4)
Twe_DIP2: D15.1 (K), R52.1, U2.10 (DIO8/PWM4)
Twe_DIP3: D17.1 (K), R54.1, U2.12 (DIO10/M1)
Twe_DIP4: D19.1 (K), R56.1, U2.15 (DIO13/DI2)
Twe_LED0: R17.2, U2.19 (DIO17/BPS)
Twe_LED1: R18.2, U2.18 (DIO16/DI4)
Twe_LED2: R19.2, U2.16 (DIO11/DI3)
VCC: C7.1, C21.1, D4.1 (K), D5.1 (K), J16.11, MD1.2 (VIN), R13.1
VDD: C20.1, D1.1 (K), D4.2 (A), Q3.2 (D), Q29.3 (S), R7.1, R86.2
V_Measure: R7.2, R8.1, U4.14 (PA0)
Vdrive: C36.1, C37.1, J13.4, J14.4, Q29.2 (D)
Volume: J15.5, R37.1, U4.24 (PC4)
主電源スイッチ: Q2.1 (G), R9.1, SW1.1 (A)

Notes on the sheet:
パスコン
Conn
Conn to LEDTape
PowerModule
ADC過電圧保護
Conn to Power
5V出力
サーボ
F446RE
電源切替/STLink
HSE
BOOT0
書き込み
DIP分岐
主電源スイッチ
TweLite
STLink
LEDTape
RS485b
Conn to sensor
TweLiteR3
レベル変換/LEDTape
MAX3485
5V生成
インジケーターLED
LED
LSE
Jumper
理想ダイオード/3.3VSYS
Capacitor
PRG
BNO055
マイコン
スライドスイッチ
理想ダイオード/5VSYS
FETのゲートの間にダイオードつけるのありかも
PullDOWN
保護回路・スイッチ
サーボ過電圧保護
TestPoint
