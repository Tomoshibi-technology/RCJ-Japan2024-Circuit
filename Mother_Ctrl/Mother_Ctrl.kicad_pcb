# Repository Tomoshibi-technology/RCJ-Japan2024-Circuit (continued)

## KiCad design Panel/Panel.kicad_pcb

Parts:
C1, C12, C14, C15: 1uF; C_0402_1005Metric
C2: 4700pF; C_0603_1608Metric
C3, C7, C10: 10uF; C_0805_2012Metric
C4, C6, C9, C13, C19, C20, C22: 0.1uF; C_0402_1005Metric
C5: 100pF; C_0603_1608Metric
C8: 470uF; CP_Radial_D10.0mm_P2.50mm_P5.00mm
C11, C23, C25: C_snub; C_0603_1608Metric
C16, C17, C18, C21: 470uF; C_Elec_8x10.2
D1, D9, D11, D13: 1N5819WS; D_SOD-323_HandSoldering
D2, D3, D4: Red; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D5, D7, D10: SS2040FL; D_SOD-123
D6: Yellow; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D8: CBD20150VCT; TO-220-3_Horizontal_TabDown
D12, D15: Green; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D16: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
H1, H3: MountingHole_Pad; TestPoint_Pad_1.5x1.5mm
H5, H6, H7, H8: MountingHole_Pad; TestPoint_THTPad_D3.0mm_Drill1.5mm
J1: Conn_01x02_Male; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J2: Conn_01x02_Female; AMASS_XT30PW-F_1x02_P2.50mm_Horizontal
J3: Conn_01x10_Male; BoxHeader_2x05_P1.27mm_Vertical_SMD
J4, J5: Conn_01x04_Male; Molex_SPOX_5268-04A_1x04_P2.50mm_Horizontal
JP1: Jumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
L1: 2.2uH; ETQ-P4M_KVK
Q1, Q3, Q4, Q8: MTP4835I3; TO-252-2
Q2, Q15: BSS138; SOT-23
Q5: 2SC3265; SOT-23
Q14: S8050; SOT-23
R1, R2, R3, R4, R5, R6, R7, R9, R10, R18, R22, R27, R30, R34, R41, R43: 10k; R_0402_1005Metric
R8: 100k; R_0402_1005Metric
R11: 33k; R_0603_1608Metric
R12: 10k; R_0603_1608Metric
R13, R14, R15, R16, R17, R29, R36, R39: 1k; R_0402_1005Metric
R19, R24, R37: R_snub; R_0603_1608Metric
R20: 510; R_0402_1005Metric
R23: 10; R_0603_1608Metric
R25: 1.5k; R_0603_1608Metric
R28: 5.1k; R_0603_1608Metric
R38, R40: 7.5k; R_0603_1608Metric
R42: 20k; R_0402_1005Metric
R44, R45: 2.2k; R_0402_1005Metric
R46: 120; R_0402_1005Metric
R47: 2k; R_0603_1608Metric
R48: 5.1k; R_0402_1005Metric
RV1: 470; PVZ3A
SW1: SW_DIP_x05; DIP-10_W7.62mm
SW2, SW5: SW_SPDT; 3P_SPDT_SlideSwitch
SW3: SW_SPDT_White; SW_Slide_SPDT_White
SW4: SW_SPST; SW_SPST_Omron_B3FS-100xP
TP1, TP2, TP3, TP4, TP5: TestPoint; TestPoint_THTPad_D2.0mm_Drill1.0mm
U1: MC34063AD; SOIC-8_3.9x4.9mm_P1.27mm
U2: AZ1084CD-3.3; TO-252-2
U3: M51957B; SOP-8_3.9x4.9mm_P1.27mm
U4: MAX3485; SOP-8_3.9x4.9mm_P1.27mm
U5: NJU6319AE; SOP-8_3.9x4.9mm_P1.27mm
U6: STM32G030K6T6; LQFP-32_7x7mm_P0.8mm
Y1: 16MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm_HandSoldering

Connections:
+3.3V: C9.1, C12.1, C15.1, C18.1, C20.1, D11.2 (A), Q14.2 (E), Q15.1 (G), R34.2, R39.2, R41.2, R44.1, SW1.6, SW1.7, SW1.8, SW1.9, SW1.10, SW2.2 (B), SW5.2 (B), TP4.1, U2.2 (VO), U4.8 (VCC), U5.1 (~CONT), U5.8 (VDD), U6.4 (VDD/VDDA)
+5V: C19.1, C21.1, D9.2 (A), D10.2 (A), D16.1 (VDD), H6.1, Q4.2 (D), R29.1, R43.2, TP2.1
/12VBAT: J1.2, J2.2, Q1.2 (D)
/S-S: C1.1, Q1.3 (S), Q3.3 (S), R3.1, R8.1, SW3.2 (B)
DIP_SW0: R1.2, SW1.1, U6.23 (PA12[PA10])
DIP_SW1: R2.2, SW1.2, U6.27 (PB3)
DIP_SW2: R4.2, SW1.3, U6.28 (PB4)
DIP_SW3: R6.2, SW1.4, U6.29 (PB5)
DIP_SW4: R7.2, SW1.5, U6.30 (PB6)
GND: C2.1, C3.2, C4.1, C5.1, C6.1, C7.2, C8.2, C9.2, C10.2, C11.1, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.1, C23.1, C25.1, D1.2 (A), D2.1 (K), D3.1 (K), D4.1 (K), D6.1 (K), D8.1 (A), D8.3 (A), D12.1 (K), D15.1 (K), D16.3 (VSS), H7.1, J1.1, J2.1, J3.4, J4.1, J4.2, J5.1, J5.2, Q1.1 (G), Q2.2 (S), R1.1, R2.1, R3.2, R4.1, R5.2, R6.1, R7.1, R10.2, R12.2, R17.2, R18.2, R25.1, R29.2, R30.2, R34.1, R42.2, R45.2, R47.2, SW4.2 (B), TP5.1, U1.2 (SwE), U1.4 (GND), U2.1 (GND), U3.4 (GND), U4.5 (GND), U5.4 (VSS), U6.5 (VSS/VSSA), Y1.2, Y1.4
LED0: R13.2, U6.18 (PA8)
LED1: R14.2, U6.22 (PA11[PA9])
LED2: R15.2, U6.20 (PC6)
LEDPannel_H: H8.1, Q15.3 (D), R43.1
LEDPannel_L: Q15.2 (S), R41.1, U6.14 (PA7)
LEDPannel_OUT: D16.4 (DIN), H5.1
MainRX1_STLinkTX: J3.8, U6.21 (PA10)
MainRX2_RS485TX: U4.1 (RO), U6.26 (PA15)
MainTX1_STLinkRX: J3.9, U6.19 (PA9)
MainTX2_RS485RX: R40.2, U4.4 (DI), U6.9 (PA2)
MonitorLED0: R16.2, U6.17 (PB2)
NRST: C13.1, H3.1, J3.6, SW4.1 (A), U6.6 (PF2-NRST)
unnamed: C1.2, Q3.1 (G), R8.2, R9.1
unnamed: C2.2, U3.5 (Cdelay)
unnamed: C3.1, C4.2, D5.1 (K), U1.6 (Vin), U1.7 (Ipk)
unnamed: C5.2, U1.3 (TC)
unnamed: C7.1, C8.1, D9.1 (K), D13.2 (A), L1.2, Q4.3 (S), R28.2, R37.2, R38.2, R48.1
unnamed: C11.2, R19.1
unnamed: C23.2, R24.1
unnamed: C25.2, R37.1
unnamed: D2.2 (A), R13.1
unnamed: D3.2 (A), R14.1
unnamed: D4.2 (A), R15.1
unnamed: D6.2 (A), R16.1
unnamed: D7.1 (K), Q5.1 (B), R20.2, U1.1 (SwC), U1.8 (DC)
unnamed: D7.2 (A), Q5.2 (E), R23.2
unnamed: D8.2 (K), L1.1, Q8.2 (D), R24.2
unnamed: D12.2 (A), R36.1
unnamed: D15.2 (A), R39.1
unnamed: D16.2 (DOUT), H1.1
unnamed: JP1.2 (B), R46.1
unnamed: Q2.3 (D), R9.2
unnamed: Q8.1 (G), R22.1, R23.1
unnamed: Q14.1 (B), R40.1
unnamed: Q14.3 (C), R42.1, U4.2 (~RE), U4.3 (DE)
unnamed: R25.2, R27.1, RV1.2
unnamed: R27.2, RV1.1
unnamed: U5.2 (XT), Y1.1
unnamed: U5.3 (~XT), Y1.3
OSC_IN: U5.5 (FOUT), U6.2 (PC14-OSCX_IN)
RS485_A: J4.3, J5.3, JP1.1 (A), R44.2, U4.6 (A)
RS485_B: J4.4, J5.4, R45.1, R46.2, U4.7 (B)
SHDN_overV: Q4.1 (G), R48.2, U3.6 (OUT)
Slide_SW0: R5.1, SW2.1 (A), U6.31 (PB7)
Slide_SW1: R18.1, SW5.1 (A), U6.32 (PB8)
TCK: J3.3, U6.25 (PA14-BOOT0)
TMS: J3.5, U6.24 (PA13)
VCC: C14.1, C17.1, D10.1 (K), D11.1 (K), R30.1, R36.2, TP3.1, U2.3 (VI)
VDD: C6.2, C10.1, C16.1, C22.2, D1.1 (K), D5.2 (A), D13.1 (K), Q3.2 (D), Q5.3 (C), Q8.3 (S), R11.1, R17.1, R19.2, R20.1, R22.2, TP1.1, U3.7 (VCC)
V_Measure: R11.2, R12.1, U6.7 (PA0)
V_Surv.: R38.1, R47.1, U3.2 (IN)
Vfb: R28.1, RV1.3, U1.5 (Vfb)
主電源スイッチ: Q2.1 (G), R10.1, SW3.1 (A)

Notes on the sheet:
5V監視
RS485
レベル変換
Crystal
I/O
MAX3485
3.3V生成
Conn to Power
パスコン
LEDPannel
マイコン
LED
PowerModule
C011F4
書き込み
TestPoint
スライドスイッチ
Capacitor
保護回路・スイッチ
NRST
STLink
5V生成
Board LED
監視LED
Conn to Display
主電源スイッチ
5Pスイッチ
インジケーターLED
Conn

Board: 2 copper layers, 90.0 x 62.0 mm, 120 parts (2 on the bottom side), 63 nets.

File Panel/jlcpcb/production_files/BOM-Panel.csv:

Comment,Designator,Footprint,LCSC
1k,"R13,R14,R15,R16,R17,R29,R36,R39",R_0402_1005Metric,C11702
16MHz,Y1,Crystal_SMD_3225-4Pin_3.2x2.5mm_HandSoldering,C13738
100pF,C5,C_0603_1608Metric,C14858
10uF,"C10,C3,C7",C_0805_2012Metric,C15850
1N5819WS,"D1,D11,D13,D9",D_SOD-323_HandSoldering,C191023
1.5k,R25,R_0603_1608Metric,C22843
10,R23,R_0603_1608Metric,C22859
2k,R47,R_0603_1608Metric,C22975
2.2uH,L1,ETQ-P4M_KVK,C230663
5.1k,R28,R_0603_1608Metric,C23186
7.5k,"R38,R40",R_0603_1608Metric,C23234
120,R46,R_0402_1005Metric,C25079
510,R20,R_0402_1005Metric,C25123
100k,R8,R_0402_1005Metric,C25741
10k,"R1,R10,R18,R2,R22,R27,R3,R30,R34,R4,R41,R43,R5,R6,R7,R9",R_0402_1005Metric,C25744
20k,R42,R_0402_1005Metric,C25765
10k,R12,R_0603_1608Metric,C25804
2.2k,"R44,R45",R_0402_1005Metric,C25879
5.1k,R48,R_0402_1005Metric,C25905
S8050,Q14,SOT-23,C3011093
0.1uF,"C13,C19,C20,C22,C4,C6,C9",C_0402_1005Metric,C307331
33k,R11,R_0603_1608Metric,C4216
BSS138,"Q15,Q2",SOT-23,C5224274
1uF,"C1,C12,C14,C15",C_0402_1005Metric,C52923
STM32G030K6T6,U6,LQFP-32_7x7mm_P0.8mm,C529331
4700pF,C2,C_0603_1608Metric,C53987
MAX3485,U4,SOP-8_3.9x4.9mm_P1.27mm,C558792
MC34063AD,U1,SOIC-8_3.9x4.9mm_P1.27mm,C71111
Red,D2,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
SS2040FL,D7,D_SOD-123,
WS2812B,D16,LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm,
MTP4835I3,Q4,TO-252-2,
TestPoint,TP4,TestPoint_THTPad_D2.0mm_Drill1.0mm,
SW_SPDT,SW5,3P_SPDT_SlideSwitch,
Jumper_2_Open,JP1,SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm,
470uF,C17,C_Elec_8x10.2,
C_snub,C25,C_0603_1608Metric,
SW_SPDT,SW2,3P_SPDT_SlideSwitch,
Conn_01x10_Male,J3,BoxHeader_2x05_P1.27mm_Vertical_SMD,
MountingHole_Pad,H5,TestPoint_THTPad_D3.0mm_Drill1.5mm,
470uF,C18,C_Elec_8x10.2,
MTP4835I3,Q8,TO-252-2,
R_snub,R19,R_0603_1608Metric,
AZ1084CD-3.3,U2,TO-252-2,
SW_DIP_x05,SW1,DIP-10_W7.62mm,
NJU6319AE,U5,SOP-8_3.9x4.9mm_P1.27mm,
C_snub,C23,C_0603_1608Metric,
SW_SPDT_White,SW3,SW_Slide_SPDT_White,
Green,D15,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
M51957B,U3,SOP-8_3.9x4.9mm_P1.27mm,
2SC3265,Q5,SOT-23,
Conn_01x04_Male,J4,Molex_SPOX_5268-04A_1x04_P2.50mm_Horizontal,
MountingHole_Pad,H6,TestPoint_THTPad_D3.0mm_Drill1.5mm,
Red,D4,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
C_snub,C11,C_0603_1608Metric,
470,RV1,PVZ3A,
470uF,C21,C_Elec_8x10.2,
CBD20150VCT,D8,TO-220-3_Horizontal_TabDown,
Yellow,D6,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
470uF,C16,C_Elec_8x10.2,
R_snub,R37,R_0603_1608Metric,
TestPoint,TP2,TestPoint_THTPad_D2.0mm_Drill1.0mm,
MTP4835I3,Q1,TO-252-2,
MTP4835I3,Q3,TO-252-2,
SW_SPST,SW4,SW_SPST_Omron_B3FS-100xP,
Conn_01x02_Male,J1,AMASS_XT30PW-M_1x02_P2.50mm_Horizontal,
TestPoint,TP3,TestPoint_THTPad_D2.0mm_Drill1.0mm,
470uF,C8,CP_Radial_D10.0mm_P2.50mm_P5.00mm,
Conn_01x02_Female,J2,AMASS_XT30PW-F_1x02_P2.50mm_Horizontal,
Green,D12,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
MountingHole_Pad,H7,TestPoint_THTPad_D3.0mm_Drill1.5mm,
R_snub,R24,R_0603_1608Metric,
Conn_01x04_Male,J5,Molex_SPOX_5268-04A_1x04_P2.50mm_Horizontal,
Red,D3,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
TestPoint,TP5,TestPoint_THTPad_D2.0mm_Drill1.0mm,
TestPoint,TP1,TestPoint_THTPad_D2.0mm_Drill1.0mm,
SS2040FL,D10,D_SOD-123,
MountingHole_Pad,H8,TestPoint_THTPad_D3.0mm_Drill1.5mm,
SS2040FL,D5,D_SOD-123,
MountingHole_Pad,H3,TestPoint_Pad_1.5x1.5mm,
MountingHole_Pad,H1,TestPoint_Pad_1.5x1.5mm,

## KiCad design Mother_UI/Mother_UI.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C17, C20: 0.1uF; C_0402_1005Metric
C15, C16: 10uF; C_0805_2012Metric
C18, C19, C21, C22: 22uF; C_0805_2012Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20: WS2812C-2020-V1
D21, D22: Yellow; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
H1, H2, H3, H4, H5, H6, H7: MountingHole_Pad; TestPoint_Pad_1.5x1.5mm
J1: Conn_01x02_Male; Molex_SPOX_5268-02A_1x02_P2.50mm_Horizontal
J2, J3, J4, J5, J6, J7: Conn_01x03_Male; Molex_SPOX_5268-03A_1x03_P2.50mm_Horizontal
J8: AudioJack3; Jack_3.5mm_Switronic_ST-005-G_horizontal
J9, J10, J11: Conn_01x12_Female; PinHeader_1x12_P2.54mm_Vertical
JP1: Jumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
LS1: Speaker; Buzzer_Murata_PKLCS1212E
Q1, Q3: S8050; SOT-23
Q2: SSM3J332R; SOT-23W
R1, R2: PullUP; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R4, R17, R18: 1k; R_0402_1005Metric
R5, R6: 5.1k; R_0402_1005Metric
R7, R8, R9, R10: 10k; R_0402_1005Metric
R11, R13: 30k; R_0603_1608Metric
R12, R14: 10k; R_0603_1608Metric
R15, R16: 47; R_0603_1608Metric
RV1: R_Potentiometer; TSR-3386K
SW1: SW_DIP_x05; DIP-10_W7.62mm
SW2, SW5: SW_SPDT; 3P_SPDT_SlideSwitch
SW3, SW4, SW6, SW8, SW9, SW10, SW11: SW_SPST; SW_SPST_Omron_B3FS-100xP
SW7: SW_SPDT_White; SW_Slide_SPDT_White
U1: OLED_akitsuki; 128×64_OLED_White
U2: NJM4580; SOP-8_3.9x4.9mm_P1.27mm

Connections:
+3.3V: C11.1, C12.1, C13.1, C14.1, J10.7, J10.12, R1.1, R2.1, RV1.3, SW1.6, SW1.7, SW1.8, SW1.9, SW1.10, SW2.2 (B), SW3.2 (B), SW4.2 (B), SW5.2 (B), SW6.2 (B), SW10.2 (B), U1.2 (VCC)
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, D1.4 (VDD), D2.4 (VDD), D3.4 (VDD), D4.4 (VDD), D5.4 (VDD), D6.4 (VDD), D7.4 (VDD), D8.4 (VDD), D9.4 (VDD), D10.4 (VDD), D11.4 (VDD), D12.4 (VDD), D13.4 (VDD), D14.4 (VDD), D15.4 (VDD), D16.4 (VDD), D17.4 (VDD), D18.4 (VDD), D19.4 (VDD), D20.4 (VDD), J2.2, J3.2, J4.2, J5.2, J6.2, J7.2, J9.10, J10.10, Q1.2 (E), Q2.3 (D)
BOOT0: H3.1, J9.4, SW10.1 (A)
DAC: J10.8, SW7.2 (B)
DAC_Amp: C18.1, JP1.1 (A), SW7.1 (A)
DAC_Jack: J8.R, J8.T, SW7.3 (C)
DIP_SW0: J11.6, SW1.1
DIP_SW1: J11.7, SW1.2
DIP_SW2: J11.8, SW1.3
DIP_SW3: J11.9, SW1.4
DIP_SW4: J11.10, SW1.5
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C13.2, C16.2, C17.2, C20.2, D1.2 (GND), D2.2 (GND), D3.2 (GND), D4.2 (GND), D5.2 (GND), D6.2 (GND), D7.2 (GND), D8.2 (GND), D9.2 (GND), D10.2 (GND), D11.2 (GND), D12.2 (GND), D13.2 (GND), D14.2 (GND), D15.2 (GND), D16.2 (GND), D17.2 (GND), D18.2 (GND), D19.2 (GND), D20.2 (GND), D21.1 (K), D22.1 (K), J1.1, J2.1, J3.1, J4.1, J5.1, J6.1, J7.1, J8.S, J9.9, J9.11, J9.12, J10.9, LS1.2, R6.1, R7.1, R8.1, R17.2, RV1.1, SW8.2 (B), SW9.2 (B), SW11.2 (B), U1.1 (GND), U2.4 (V-)
GNDA: C15.2, C16.1, R5.1, R6.2, R9.1, R10.1, R12.2, R14.2, R18.2
I2C1_SCL: J11.2, R1.2, U1.3 (SCL)
I2C1_SDA: J11.1, R2.2, U1.4 (SDA)
LEDTape1_H: J5.3, J10.1
LEDTape2_H: J6.3, J9.1
LEDTape3_H: J7.3, J11.4
MonitorLED0: J10.5, R3.2
MonitorLED1: J9.6, R4.2
NRST: C20.1, H2.1, J11.5, SW11.1 (A)
NeoPixel_H: D1.3 (DIN), J11.3
unnamed: C18.2, R9.2, U2.3 (+)
unnamed: C19.1, JP1.2 (B)
unnamed: C19.2, R10.2, U2.5 (+)
unnamed: C21.1, R15.2
unnamed: C21.2, LS1.1, R17.1
unnamed: C22.1, R16.2
unnamed: C22.2, H4.1, R18.1
unnamed: D1.1 (DOUT), D5.3 (DIN)
unnamed: D2.1 (DOUT), D6.3 (DIN)
unnamed: D3.1 (DOUT), D7.3 (DIN)
unnamed: D4.1 (DOUT), D8.3 (DIN)
unnamed: D5.1 (DOUT), D9.3 (DIN)
unnamed: D10.1 (DOUT), D14.3 (DIN)
unnamed: D6.1 (DOUT), D10.3 (DIN)
unnamed: D11.1 (DOUT), D15.3 (DIN)
unnamed: D7.1 (DOUT), D11.3 (DIN)
unnamed: D12.1 (DOUT), D16.3 (DIN)
unnamed: D8.1 (DOUT), D12.3 (DIN)
unnamed: D13.1 (DOUT), D17.3 (DIN)
unnamed: D9.1 (DOUT), D13.3 (DIN)
unnamed: D14.1 (DOUT), D18.3 (DIN)
unnamed: D15.1 (DOUT), D19.3 (DIN)
unnamed: D16.1 (DOUT), D20.3 (DIN)
unnamed: D2.3 (DIN), D17.1 (DOUT)
unnamed: D3.3 (DIN), D18.1 (DOUT)
unnamed: D4.3 (DIN), D19.1 (DOUT)
unnamed: D20.1 (DOUT), H1.1
unnamed: D21.2 (A), R3.1
unnamed: D22.2 (A), R4.1
unnamed: J1.2, Q2.2 (S), Q3.2 (E)
unnamed: Q1.1 (B), Q1.3 (C), Q3.1 (B), R7.2
unnamed: Q2.1 (G), Q3.3 (C), R8.2
unnamed: R11.1, R15.1, U2.1
unnamed: R11.2, R12.1, U2.2 (-)
unnamed: R13.1, R16.1, U2.7
unnamed: R13.2, R14.1, U2.6 (-)
PRG: J11.11, SW9.1 (A)
RST: C17.1, J11.12, SW8.1 (A)
Sensor1: H5.1, J2.3, J9.7
Sensor2: H6.1, J3.3, J9.8
Sensor3: H7.1, J4.3, J10.6
Slide_SW1: J9.2, SW2.1 (A)
Slide_SW2: J9.3, SW5.1 (A)
Tact_SW0: C11.2, J10.3, SW3.1 (A)
Tact_SW1: C12.2, J10.4, SW4.1 (A)
Tact_SW2: C14.2, J10.2, SW6.1 (A)
VCC: C15.1, J10.11, R5.2, U2.8 (V+)
Volume: J9.5, RV1.2

Notes on the sheet:
仮想GND
RST
F446_NRST/BOOT
NeoPixel
Conn to sensor
BOOT0
I/O
OLED
5V出力
しょぼアンプ
スライドスイッチ
PRG
監視LED
Conn to LEDTape
DACスイッチ
Twe_RST/PRG
NRST
アンプ
基板間コネクタ
LEDTape
モニター
5Pスイッチ
モニター用タクトスイッチ
パスコン
Volume
Audio
