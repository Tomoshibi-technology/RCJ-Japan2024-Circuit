# Repository Tomoshibi-technology/RCJ-Japan2024-Circuit (continued)

## KiCad design Pole/Pole.kicad_pcb

Parts:
C1, C10, C11, C12: 1uF; C_0402_1005Metric
C2: 4700pF; C_0603_1608Metric
C3, C8, C19, C27, C34: 10uF; C_0805_2012Metric
C4, C5, C6, C14, C15, C16, C21, C22, C23, C24, C25, C26, C29, C31: 0.1uF; C_0402_1005Metric
C7: ADJ_ST; C_0603_1608Metric
C9, C32, C36: C_snub; C_0603_1608Metric
C13: 22uF; C_0805_2012Metric
C17: C; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C18, C28: 470uF; C_Elec_8x10.2
C30: 100pF; C_0603_1608Metric
C35: 470uF; CP_Radial_D10.0mm_P2.50mm_P5.00mm
D1: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D2, D9, D11, D16, D17, D29: 1N5819WS; D_SOD-323_HandSoldering
D3, D8: SS2040FL; D_SOD-123
D4, D5, D6: Red; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D7: Yellow; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D10: D_Zener; D_SOD-323_HandSoldering
D12, D13, D14, D15: Green; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D18, D19, D20, D21, D22, D23, D24, D25, D26, D27: WS2812C-2020-V1
D28: CBD20150VCT; TO-220-3_Horizontal_TabDown
F1: Fuse; FUC_03A
H3, H4, H5, H6, H7: MountingHole_Pad; TestPoint_Pad_1.5x1.5mm
J1: Conn_01x02_Male; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J2, J3: Conn_01x02_Female; AMASS_XT30PW-F_1x02_P2.50mm_Horizontal
J4: USB_C_Receptacle_USB2.0; USB_C_Receptacle_G-Switch_GT-USB-7010ASV
J6: AudioJack3; Jack_3.5mm_Switronic_ST-005-G_horizontal
J7, J8: Conn_01x03_Male; Molex_SPOX_5268-03A_1x03_P2.50mm_Horizontal
J9, J10, J11: Conn_01x03_Male; Molex_SPOX_5267-03A_1x03_P2.50mm_Vertical
J12, J13: Conn_01x04_Male; Molex_SPOX_5268-04A_1x04_P2.50mm_Horizontal
JP1, JP3: Jumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
JP2: Jumper_2_Open; PinHeader_1x02_P2.54mm_Vertical
L1: 2.2uH; ETQ-P4M_KVK
Q1, Q3, Q8, Q21: MTP4835I3; TO-252-2
Q2, Q9, Q10, Q16, Q18, Q19, Q20: BSS138; SOT-23
Q4, Q7, Q12, Q14: SSM3J332R; SOT-23W
Q5: 2SC3265; SOT-23
Q6, Q11, Q13, Q15, Q17: S8050; SOT-23
R1, R18, R19, R22, R23, R27, R29, R33, R42, R43, R44, R45: 1k; R_0402_1005Metric
R2, R4, R5, R6, R7, R8, R11, R12, R13, R16, R17, R21, R24, R25, R26, R28, R30, R31, R36, R37, R38, R39, R40, R46, R47, R50, R51, R52, R53, R54, R55, R60, R69: 10k; R_0402_1005Metric
R3, R35: 100k; R_0402_1005Metric
R9: 33k; R_0603_1608Metric
R10: 10k; R_0603_1608Metric
R14, R15, R73: 5.1k; R_0402_1005Metric
R20, R61, R67: R_snub; R_0603_1608Metric
R32: 510; R_0402_1005Metric
R48, R71: 7.5k; R_0603_1608Metric
R49: 20k; R_0402_1005Metric
R56, R57: 2.2k; R_0402_1005Metric
R58: 120; R_0402_1005Metric
R59: 10; R_0603_1608Metric
R68: 1.5k; R_0603_1608Metric
R70: 5.1k; R_0603_1608Metric
R72: 2k; R_0603_1608Metric
RV1: 470; PVZ3A
SW1: SW_DIP_x05; DIP-10_W7.62mm
SW2: SW_SPDT; 3P_SPDT_5Pin_ToggleSwitch
SW3, SW6: SW_SPDT; 3P_SPDT_SlideSwitch
SW4, SW5: SW_SPST; SW_SPST_Omron_B3FS-100xP
TP5: TestPoint; TestPoint_THTPad_D2.0mm_Drill1.0mm
U1: M51957B; SOP-8_3.9x4.9mm_P1.27mm
U2: CH340K
U3: AZ1084CD-3.3; TO-252-2
U4: ESP32-WROOM-32
U5: MAX3485; SOP-8_3.9x4.9mm_P1.27mm
U6: MC34063AD; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3.3V: C5.2, C12.1, C13.1, C16.1, C19.1, C26.1, D11.2 (A), D16.1 (K), D17.1 (K), JP1.1 (A), Q16.1 (G), Q17.2 (E), Q18.1 (G), Q19.1 (G), Q20.1 (G), R31.1, R38.2, R39.1, R45.2, R46.2, R50.2, R51.2, R52.2, R56.1, SW1.6, SW1.7, SW1.8, SW1.9, SW1.10, SW3.2 (B), SW6.2 (B), U2.7 (VCC), U3.2 (VO), U4.2 (VDD), U5.8 (VCC)
+5V: C11.1, C21.1, C22.1, C23.1, C24.1, C25.1, C28.1, D10.1 (K), D11.1 (K), D18.4 (VDD), D19.4 (VDD), D20.4 (VDD), D21.4 (VDD), D22.4 (VDD), D23.4 (VDD), D24.4 (VDD), D25.4 (VDD), D26.4 (VDD), D27.4 (VDD), J7.2, J8.2, Q7.2 (S), Q11.2 (E), Q14.2 (S), Q15.2 (E), R30.2, R44.2, R47.2, R53.2, R54.2, R55.2, U3.3 (VI)
/5VBUS: C3.2, J4.A4 (VBUS), J4.A9 (VBUS), J4.B4 (VBUS), J4.B9 (VBUS), Q4.2 (S), R16.2
/5VBUS_fetB: JP3.2 (B), Q7.1 (G), Q11.3 (C), R28.2
/5VBUS_fetF: C7.2, JP3.1 (A), Q4.1 (G), R17.2
/5VSYS: C10.1, D9.2 (A), J9.2, J10.2, J11.2, Q12.2 (S), Q21.2 (D), R17.1, R18.1, R33.1, R35.1, R42.2
/5V_IND: Q4.3 (D), Q6.2 (E), Q7.3 (D), R24.2, R43.2
/12VBAT: F1.2, J1.2, J2.2, J3.2
/S-S: C1.1, Q1.3 (S), Q3.3 (S), R2.1, R3.1, SW2.2 (B)
DAC_L: J6.T, U4.10 (IO25)
DAC_R: J6.R, U4.11 (IO26)
DIP_SW0: R5.2, SW1.1, U4.26 (IO4)
DIP_SW1: R6.2, SW1.2, U4.12 (IO27)
DIP_SW2: R8.2, SW1.3, U4.9 (IO33)
DIP_SW3: R11.2, SW1.4, U4.5 (SENSOR_VN)
DIP_SW4: R12.2, SW1.5, U4.4 (SENSOR_VP)
GND: C2.1, C3.1, C4.1, C5.1, C6.2, C7.1, C8.2, C9.1, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.1, C18.2, C19.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.1, C30.1, C31.1, C32.1, C34.2, C35.2, C36.1, D1.1 (K), D2.2 (A), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D10.2 (A), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D18.2 (GND), D19.2 (GND), D20.2 (GND), D21.2 (GND), D22.2 (GND), D23.2 (GND), D24.2 (GND), D25.2 (GND), D26.2 (GND), D27.2 (GND), D28.1 (A), D28.3 (A), J1.1, J2.1, J3.1, J4.A1 (GND), J4.A12 (GND), J4.B1 (GND), J4.B12 (GND), J4.S1 (SHIELD), J6.S, J7.1, J8.1, J9.1, J10.1, J11.1, J12.1, J12.2, J13.1, J13.2, Q1.1 (G), Q2.2 (S), R2.2, R5.1, R6.1, R7.2, R8.1, R10.2, R11.1, R12.1, R13.2, R14.1, R15.1, R16.1, R18.2, R19.2, R21.2, R24.1, R25.1, R28.1, R30.1, R33.2, R36.2, R37.1, R38.1, R40.1, R49.2, R57.2, R68.1, R72.2, SW4.2 (B), SW5.2 (B), TP5.1, U1.4 (GND), U2.3 (GND), U2.11 (EP), U3.1 (GND), U4.1 (GND), U4.15 (GND), U4.38 (GND), U4.39 (GND), U5.5 (GND), U6.2 (SwE), U6.4 (GND)
IO0: C15.1, H4.1, Q10.3 (D), R31.2, SW5.1 (A), U4.25 (IO0)
LED0: R22.2, U4.16 (IO13)
LED1: R23.2, U4.14 (IO12)
LED2: R27.2, U4.13 (IO14)
LEDTape0_H: J9.3, Q18.3 (D), R53.1
LEDTape0_L: Q18.2 (S), R50.1, U4.30 (IO18)
LEDTape1_H: J10.3, Q19.3 (D), R54.1
LEDTape1_L: Q19.2 (S), R51.1, U4.33 (IO21)
LEDTape2_H: J11.3, Q20.3 (D), R55.1
LEDTape2_L: Q20.2 (S), R52.1, U4.31 (IO19)
MainRX0_CH340TX: U2.8 (TXD), U4.34 (RXD0/IO3)
MainRX2_RS485TX: U4.27 (IO16), U5.1 (RO)
MainTX0_CH340RX: U2.9 (RXD), U4.35 (TXD0/IO1)
MainTX2_RS485RX: R48.2, U4.28 (IO17), U5.4 (DI)
MonitorLED0: R29.2, U4.24 (IO2)
NeoPixel_H: D18.3 (DIN), Q16.3 (D), R47.1
NeoPixel_L: Q16.2 (S), R46.1, U4.23 (IO15)
unnamed: C1.2, Q3.1 (G), R3.2, R4.1
unnamed: C2.2, U1.5 (Cdelay)
unnamed: C6.1, JP1.2 (B), U2.10 (V3)
unnamed: C9.2, R20.1
unnamed: C10.2, Q12.1 (G), R35.2, R36.1
unnamed: C27.1, C29.2, D3.1 (K), U6.6 (Vin), U6.7 (Ipk)
unnamed: C30.2, U6.3 (TC)
unnamed: C32.2, R61.1
unnamed: C34.1, C35.1, D9.1 (K), D29.2 (A), L1.2, Q21.3 (S), R67.2, R70.2, R71.2, R73.1
unnamed: C36.2, R67.1
unnamed: D1.2 (A), R1.1
unnamed: D4.2 (A), R22.1
unnamed: D5.2 (A), R23.1
unnamed: D6.2 (A), R27.1
unnamed: D7.2 (A), R29.1
unnamed: D8.1 (K), Q5.1 (B), R32.2, U6.1 (SwC), U6.8 (DC)
unnamed: D8.2 (A), Q5.2 (E), R59.2
unnamed: D12.2 (A), R42.1
unnamed: D13.2 (A), R43.1
unnamed: D14.2 (A), R44.1
unnamed: D15.2 (A), R45.1
unnamed: D18.1 (DOUT), D20.3 (DIN)
unnamed: D19.1 (DOUT), D21.3 (DIN)
unnamed: D19.3 (DIN), D26.1 (DOUT)
unnamed: D20.1 (DOUT), D22.3 (DIN)
unnamed: D21.1 (DOUT), D23.3 (DIN)
unnamed: D22.1 (DOUT), D24.3 (DIN)
unnamed: D23.1 (DOUT), D25.3 (DIN)
unnamed: D24.1 (DOUT), D26.3 (DIN)
unnamed: D25.1 (DOUT), D27.3 (DIN)
unnamed: D27.1 (DOUT), H5.1
unnamed: D28.2 (K), L1.1, Q8.2 (D), R61.2
unnamed: F1.1, Q1.2 (D)
unnamed: J4.A5 (CC1), R15.2
unnamed: J4.A6 (D+), J4.B6 (D+), U2.1 (UD+)
unnamed: J4.A7 (D-), J4.B7 (D-), U2.2 (UD-)
unnamed: J4.B5 (CC2), R14.2
unnamed: JP2.2 (B), R58.1
unnamed: Q2.3 (D), R4.2
unnamed: Q8.1 (G), R59.1, R60.1
unnamed: Q9.2 (S), Q10.1 (G), R26.2, U2.6 (~RTS)
unnamed: Q9.1 (G), Q10.2 (S), R26.1, U2.4 (~DTR)
unnamed: Q6.1 (B), Q6.3 (C), Q11.1 (B), R25.2
unnamed: Q12.3 (D), Q13.2 (E), Q14.3 (D)
unnamed: Q13.1 (B), Q13.3 (C), Q15.1 (B), R37.2
unnamed: Q14.1 (G), Q15.3 (C), R40.2
unnamed: Q17.1 (B), R48.1
unnamed: Q17.3 (C), R49.1, U5.2 (~RE), U5.3 (DE)
unnamed: R68.2, R69.1, RV1.2
unnamed: R69.2, RV1.1
RESET: C14.1, C17.2, H3.1, Q9.3 (D), R39.2, SW4.1 (A), U4.3 (EN)
RS485_A: J12.3, J13.3, R56.2, R58.2, U5.6 (A)
RS485_B: J12.4, J13.4, JP2.1 (A), R57.1, U5.7 (B)
SHDN_overV: Q21.1 (G), R73.2, U1.6 (OUT)
Sensor0: D16.2 (A), H6.1, J7.3, U4.7 (IO35)
Sensor1: D17.2 (A), H7.1, J8.3, U4.6 (IO34)
Slide_SW0: R13.1, SW3.1 (A), U4.36 (IO22)
Slide_SW1: R21.1, SW6.1 (A), U4.37 (IO23)
VDD: C4.2, C8.1, C18.1, C31.2, D2.1 (K), D3.2 (A), D29.1 (K), Q3.2 (D), Q5.3 (C), Q8.3 (S), R1.2, R9.1, R19.1, R20.2, R32.1, R60.2, U1.7 (VCC)
V_Measure: R9.2, R10.1, U4.8 (IO32)
V_Surv.: R71.1, R72.1, U1.2 (IN)
Vfb: R70.1, RV1.3, U6.5 (Vfb)
主電源スイッチ: Q2.1 (G), R7.1, SW2.1 (A)

Notes on the sheet:
RST
RS485
パスコン
I/O
電源切替/USB
PowerModule
Conn to LEDTape
5V生成
マイコン
レベル変換
NeoPixel
書き込み
理想ダイオード/5VSYS
LED
主電源スイッチ
インジケーターLED
5Pスイッチ
Conn to Power
監視LED
スライドスイッチ
5V監視
MAX3485
保護回路・スイッチ
TestPoint
Conn
Audio
LEDTape
Conn to sensor
3.3V生成
Capacitor
BOOT

Board: 2 copper layers, 100.0 x 70.0 mm, 186 parts (5 on the bottom side), 97 nets.

File Pole/jlcpcb/production_files/BOM-Pole.csv:

Comment,Designator,Footprint,LCSC
1k,"R1,R18,R19,R22,R23,R27,R29,R33,R42,R43,R44,R45",R_0402_1005Metric,C11702
SSM3J332R,"Q12,Q14,Q4,Q7",SOT-23W,C146367
ADJ_ST,C7,C_0603_1608Metric,C14663
100pF,C30,C_0603_1608Metric,C14858
10uF,"C19,C27,C3,C34,C8",C_0805_2012Metric,C15850
CH340K,U2,CH340K,C18208922
1N5819WS,"D11,D16,D17,D2,D29,D9",D_SOD-323_HandSoldering,C191023
1.5k,R68,R_0603_1608Metric,C22843
10,R59,R_0603_1608Metric,C22859
2k,R72,R_0603_1608Metric,C22975
2.2uH,L1,ETQ-P4M_KVK,C230663
5.1k,R70,R_0603_1608Metric,C23186
7.5k,"R48,R71",R_0603_1608Metric,C23234
120,R58,R_0402_1005Metric,C25079
510,R32,R_0402_1005Metric,C25123
100k,"R3,R35",R_0402_1005Metric,C25741
10k,"R11,R12,R13,R16,R17,R2,R21,R24,R25,R26,R28,R30,R31,R36,R37,R38,R39,R4,R40,R46,R47,R5,R50,R51,R52,R53,R54,R55,R6,R60,R69,R7,R8",R_0402_1005Metric,C25744
20k,R49,R_0402_1005Metric,C25765
10k,R10,R_0603_1608Metric,C25804
2.2k,"R56,R57",R_0402_1005Metric,C25879
5.1k,"R14,R15,R73",R_0402_1005Metric,C25905
WS2812C-2020-V1,"D18,D19,D20,D21,D22,D23,D24,D25,D26,D27",WS2812C-2020-V1,C2976072
S8050,"Q11,Q13,Q15,Q17,Q6",SOT-23,C3011093
0.1uF,"C14,C15,C16,C21,C22,C23,C24,C25,C26,C29,C31,C4,C5,C6",C_0402_1005Metric,C307331
33k,R9,R_0603_1608Metric,C4216
22uF,C13,C_0805_2012Metric,C45783
BSS138,"Q10,Q16,Q18,Q19,Q2,Q20,Q9",SOT-23,C5224274
1uF,"C1,C10,C11,C12",C_0402_1005Metric,C52923
4700pF,C2,C_0603_1608Metric,C53987
MAX3485,U5,SOP-8_3.9x4.9mm_P1.27mm,C558792
MC34063AD,U6,SOIC-8_3.9x4.9mm_P1.27mm,C71111
USB_C_Receptacle_USB2.0,J4,USB_C_Receptacle_G-Switch_GT-USB-7010ASV,C963412
SW_SPDT,SW2,3P_SPDT_5Pin_ToggleSwitch,
Green,D14,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
Yellow,D7,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
Conn_01x04_Male,J13,Molex_SPOX_5268-04A_1x04_P2.50mm_Horizontal,
R_snub,R67,R_0603_1608Metric,
AudioJack3,J6,Jack_3.5mm_Switronic_ST-005-G_horizontal,
C_snub,C36,C_0603_1608Metric,
C_snub,C9,C_0603_1608Metric,
Conn_01x03_Male,J11,Molex_SPOX_5267-03A_1x03_P2.50mm_Vertical,
C_snub,C32,C_0603_1608Metric,
TestPoint,TP5,TestPoint_THTPad_D2.0mm_Drill1.0mm,
SW_SPST,SW4,SW_SPST_Omron_B3FS-100xP,
Red,D5,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
AZ1084CD-3.3,U3,TO-252-2,
SW_SPDT,SW6,3P_SPDT_SlideSwitch,
M51957B,U1,SOP-8_3.9x4.9mm_P1.27mm,
SS2040FL,D8,D_SOD-123,
C,C17,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,
470uF,C18,C_Elec_8x10.2,
R_snub,R20,R_0603_1608Metric,
Jumper_2_Open,JP3,SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm,
MountingHole_Pad,H5,TestPoint_Pad_1.5x1.5mm,
D_Zener,D10,D_SOD-323_HandSoldering,
Conn_01x04_Male,J12,Molex_SPOX_5268-04A_1x04_P2.50mm_Horizontal,
470uF,C28,C_Elec_8x10.2,
MTP4835I3,Q3,TO-252-2,
Conn_01x03_Male,J10,Molex_SPOX_5267-03A_1x03_P2.50mm_Vertical,
470uF,C35,CP_Radial_D10.0mm_P2.50mm_P5.00mm,
LED,D1,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
MTP4835I3,Q1,TO-252-2,
SW_SPDT,SW3,3P_SPDT_SlideSwitch,
Conn_01x03_Male,J9,Molex_SPOX_5267-03A_1x03_P2.50mm_Vertical,
Conn_01x02_Male,J1,AMASS_XT30PW-M_1x02_P2.50mm_Horizontal,
Fuse,F1,FUC_03A,
Green,D12,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
SW_DIP_x05,SW1,DIP-10_W7.62mm,
Conn_01x02_Female,J3,AMASS_XT30PW-F_1x02_P2.50mm_Horizontal,
MTP4835I3,Q8,TO-252-2,
CBD20150VCT,D28,TO-220-3_Horizontal_TabDown,
2SC3265,Q5,SOT-23,
Conn_01x03_Male,J8,Molex_SPOX_5268-03A_1x03_P2.50mm_Horizontal,
Jumper_2_Open,JP2,PinHeader_1x02_P2.54mm_Vertical,
Conn_01x02_Female,J2,AMASS_XT30PW-F_1x02_P2.50mm_Horizontal,
MTP4835I3,Q21,TO-252-2,
Red,D4,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
470,RV1,PVZ3A,
Green,D13,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
R_snub,R61,R_0603_1608Metric,
Conn_01x03_Male,J7,Molex_SPOX_5268-03A_1x03_P2.50mm_Horizontal,
Red,D6,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
ESP32-WROOM-32,U4,ESP32-WROOM-32,
SW_SPST,SW5,SW_SPST_Omron_B3FS-100xP,
Green,D15,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
SS2040FL,D3,D_SOD-123,
MountingHole_Pad,H7,TestPoint_Pad_1.5x1.5mm,
MountingHole_Pad,H6,TestPoint_Pad_1.5x1.5mm,
Jumper_2_Open,JP1,SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm,
MountingHole_Pad,H4,TestPoint_Pad_1.5x1.5mm,
MountingHole_Pad,H3,TestPoint_Pad_1.5x1.5mm,
