# Repository Tomoshibi-technology/RCJ-Japan2024-Circuit (continued)

## KiCad design Mother_UI/Mother_UI.kicad_pcb (continued)

Board: 2 copper layers, 100.0 x 60.0 mm, 99 parts (9 on the bottom side), 70 nets.

File Mother_UI/jlcpcb/production_files/BOM-Mother_UI.csv:

Comment,Designator,Footprint,LCSC
1k,"R17,R18,R3,R4",R_0402_1005Metric,C11702
SSM3J332R,Q2,SOT-23W,C146367
0.1uF,"C1,C10,C11,C12,C13,C14,C17,C2,C20,C3,C4,C5,C6,C7,C8,C9",C_0402_1005Metric,C1525
10uF,"C15,C16",C_0805_2012Metric,C15850
30k,"R11,R13",R_0603_1608Metric,C22984
47,"R15,R16",R_0603_1608Metric,C23182
10k,"R10,R7,R8,R9",R_0402_1005Metric,C25744
PullUP,"R1,R12,R14,R2",R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C25804
5.1k,"R5,R6",R_0402_1005Metric,C25905
WS2812C-2020-V1,"D1,D10,D11,D12,D13,D14,D15,D16,D17,D18,D19,D2,D20,D3,D4,D5,D6,D7,D8,D9",WS2812C-2020-V1,C2976072
S8050,"Q1,Q3",SOT-23,C3011093
22uF,"C18,C19,C21,C22",C_0805_2012Metric,C45783
SW_SPDT_White,SW7,SW_Slide_SPDT_White,
SW_SPST,SW8,SW_SPST_Omron_B3FS-100xP,
Conn_01x03_Male,J7,Molex_SPOX_5268-03A_1x03_P2.50mm_Horizontal,
Speaker,LS1,Buzzer_Murata_PKLCS1212E,
OLED_akitsuki,U1,128×64_OLED_White,
Conn_01x03_Male,J6,Molex_SPOX_5268-03A_1x03_P2.50mm_Horizontal,
SW_SPST,SW4,SW_SPST_Omron_B3FS-100xP,
SW_SPDT,SW2,3P_SPDT_SlideSwitch,
Jumper_2_Open,JP1,SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm,
MountingHole_Pad,H4,TestPoint_Pad_1.5x1.5mm,
Conn_01x03_Male,J2,Molex_SPOX_5268-03A_1x03_P2.50mm_Horizontal,
SW_SPST,SW11,SW_SPST_Omron_B3FS-100xP,
AudioJack3,J8,Jack_3.5mm_Switronic_ST-005-G_horizontal,
Yellow,D22,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
Conn_01x03_Male,J3,Molex_SPOX_5268-03A_1x03_P2.50mm_Horizontal,
R_Potentiometer,RV1,TSR-3386K,
SW_SPST,SW6,SW_SPST_Omron_B3FS-100xP,
SW_SPST,SW3,SW_SPST_Omron_B3FS-100xP,
Conn_01x03_Male,J5,Molex_SPOX_5268-03A_1x03_P2.50mm_Horizontal,
Yellow,D21,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
Conn_01x02_Male,J1,Molex_SPOX_5268-02A_1x02_P2.50mm_Horizontal,
Conn_01x03_Male,J4,Molex_SPOX_5268-03A_1x03_P2.50mm_Horizontal,
SW_DIP_x05,SW1,DIP-10_W7.62mm,
SW_SPST,SW10,SW_SPST_Omron_B3FS-100xP,
SW_SPDT,SW5,3P_SPDT_SlideSwitch,
SW_SPST,SW9,SW_SPST_Omron_B3FS-100xP,
NJM4580,U2,SOP-8_3.9x4.9mm_P1.27mm,
Conn_01x12_Female,J10,PinHeader_1x12_P2.54mm_Vertical,
MountingHole_Pad,H6,TestPoint_Pad_1.5x1.5mm,
MountingHole_Pad,H3,TestPoint_Pad_1.5x1.5mm,
MountingHole_Pad,H5,TestPoint_Pad_1.5x1.5mm,
MountingHole_Pad,H7,TestPoint_Pad_1.5x1.5mm,
MountingHole_Pad,H2,TestPoint_Pad_1.5x1.5mm,
Conn_01x12_Female,J9,PinHeader_1x12_P2.54mm_Vertical,
Conn_01x12_Female,J11,PinHeader_1x12_P2.54mm_Vertical,
MountingHole_Pad,H1,TestPoint_Pad_1.5x1.5mm,

## KiCad design LED_lighting_large/LED_lighting_large.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16: WS2812C-2020-V1
J1, J2: Conn_01x03_Pin; JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical

Connections:
DIN: D1.3 (DIN), J1.3
DOUT: D16.1 (DOUT), J2.3
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, D1.2 (GND), D2.2 (GND), D3.2 (GND), D4.2 (GND), D5.2 (GND), D6.2 (GND), D7.2 (GND), D8.2 (GND), D9.2 (GND), D10.2 (GND), D11.2 (GND), D12.2 (GND), D13.2 (GND), D14.2 (GND), D15.2 (GND), D16.2 (GND), J1.1, J2.1
unnamed: D1.1 (DOUT), D2.3 (DIN)
unnamed: D2.1 (DOUT), D3.3 (DIN)
unnamed: D3.1 (DOUT), D4.3 (DIN)
unnamed: D4.1 (DOUT), D5.3 (DIN)
unnamed: D5.1 (DOUT), D6.3 (DIN)
unnamed: D6.1 (DOUT), D7.3 (DIN)
unnamed: D7.1 (DOUT), D8.3 (DIN)
unnamed: D8.1 (DOUT), D9.3 (DIN)
unnamed: D9.1 (DOUT), D10.3 (DIN)
unnamed: D10.1 (DOUT), D11.3 (DIN)
unnamed: D11.1 (DOUT), D12.3 (DIN)
unnamed: D12.1 (DOUT), D13.3 (DIN)
unnamed: D13.1 (DOUT), D14.3 (DIN)
unnamed: D14.1 (DOUT), D15.3 (DIN)
unnamed: D15.1 (DOUT), D16.3 (DIN)
VDD: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, D1.4 (VDD), D2.4 (VDD), D3.4 (VDD), D4.4 (VDD), D5.4 (VDD), D6.4 (VDD), D7.4 (VDD), D8.4 (VDD), D9.4 (VDD), D10.4 (VDD), D11.4 (VDD), D12.4 (VDD), D13.4 (VDD), D14.4 (VDD), D15.4 (VDD), D16.4 (VDD), J1.2, J2.2

Notes on the sheet:
LED
Connector
パスコン

Board: 2 copper layers, 94.0 x 94.0 mm, 34 parts (2 on the bottom side), 19 nets.

File LED_lighting_large/jlcpcb/production_files/BOM-LED_lighting_large.csv:

Comment,Designator,Footprint,LCSC
WS2812C-2020-V1,"D1,D10,D11,D12,D13,D14,D15,D16,D2,D3,D4,D5,D6,D7,D8,D9",WS2812C-2020-V1,C2976072
0.1uF,"C1,C10,C11,C12,C13,C14,C15,C16,C2,C3,C4,C5,C6,C7,C8,C9",C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,C66501
Conn_01x03_Pin,J2,JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical,
Conn_01x03_Pin,J1,JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical,

## KiCad design connect/connect.kicad_pcb

Board: 2 copper layers, 29.0 x 29.0 mm, 4 parts (2 on the bottom side), 5 nets.

Parts:
J2: Conn_01x03_Pin; JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical
J4: Conn_01x03_Pin; Molex_SPOX_5267-03A_1x03_P2.50mm_Vertical
LED: Conn_01x03_Pin; JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical
SERVO: Conn_01x03_Pin; Molex_SPOX_5267-03A_1x03_P2.50mm_Vertical

Connections:
GND: J2.1, J4.1, LED.1, SERVO.1
unnamed: J2.2, LED.2
unnamed: J2.3, LED.3
unnamed: J4.2, SERVO.2
unnamed: J4.3, SERVO.3
