# Repository Tomoshibi-technology/RCJ-Japan2024-Circuit (continued)

## KiCad design LargeMD/LargeMD.kicad_pcb

Parts:
C1, C4, C5, C6, C11, C31: 1uF; C_0402_1005Metric
C3, C20, C21: 10uF; C_0805_2012Metric
C7, C10, C22, C23, C24, C25, C26, C27, C28: 0.1uF; C_0402_1005Metric
C13, C14, C15, C16, C17, C18, C19: 470uF; C_Elec_8x10.2
C29, C30: C; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
D1, D7, D8, D9, D15: 1N5819WS; D_SOD-323_HandSoldering
D2: MA10EB045; DO-221BC
D3, D4, D5, D18, D19: Red; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D6: Yellow; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D11, D14: Green; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D16, D17, D20, D21, D22, D23: SS2040FL; D_SOD-123
H2: MountingHole_Pad; TestPoint_Pad_1.5x1.5mm
J1: Conn_01x02_Male; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J2, J6: Conn_01x02_Female; AMASS_XT30PW-F_1x02_P2.50mm_Horizontal
J3: Conn_01x10_Male; BoxHeader_2x05_P1.27mm_Horizontal
J4: Conn_01x02_Male; Molex_SPOX_5267-02A_1x02_P2.50mm_Vertical
J5: Conn_01x03_Male; Molex_SPOX_5268-03A_1x03_P2.50mm_Horizontal
J7, J8: Conn_01x04_Male; Molex_SPOX_5268-04A_1x04_P2.50mm_Horizontal
J9, J10: Conn_01x04_Male; Molex_SPOX_5267-04A_1x04_P2.50mm_Vertical
JP1, JP2: SolderJumper_3_Bridged12; SolderJumper-3_P2.0mm_Open_TrianglePad1.0x1.5mm_NumberLabels
JP3, JP4: Jumper_2_Open; PinHeader_1x02_P2.54mm_Vertical
Q1, Q3: TJ60S04M3L; TO-252-2
Q2, Q17, Q18: BSS138; SOT-23
Q4, Q6, Q15, Q16: S8050; SOT-23
Q5: SSM3J332R; SOT-23W
Q19, Q20, Q21, Q22: TPH3R704PL; SOP-Advance
R1, R2, R3, R4, R5, R6, R7, R9, R10, R17, R18, R19, R20, R22, R43, R44, R54, R55, R63, R64, R65, R66, R67: 10k; R_0402_1005Metric
R8: 100k; R_0402_1005Metric
R11: 33k; R_0603_1608Metric
R12: 10k; R_0603_1608Metric
R13, R14, R15, R16, R33, R36: 1k; R_0402_1005Metric
R37, R68: 20mR; R_2512_6332Metric
R38, R39, R58, R59, R60, R61: 47; R_0603_1608Metric
R40, R41: 7.5k; R_0603_1608Metric
R42: 39; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R45, R46: 20k; R_0402_1005Metric
R47, R48: 470; R_0402_1005Metric
R49: 3.3k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R50, R51, R52, R53: 2.2k; R_0402_1005Metric
R56, R57: 120; R_0402_1005Metric
R62: MPR; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
SW1: SW_DIP_x05; DIP-10_W7.62mm
SW2: SW_SPDT; 3P_SPDT_SlideSwitch
SW3: SW_SPDT; 3P_SPDT_5Pin_ToggleSwitch
SW4: SW_SPST; SW_SPST_Omron_B3FS-100xP
TP4, TP5: TestPoint; TestPoint_THTPad_D2.0mm_Drill1.0mm
U1: LF50_TO220; BP5293
U2: AZ1084CD-3.3; TO-252-3_TabPin2
U3: STM32G030K6T6; LQFP-32_7x7mm_P0.8mm
U4: LT6106; SOT-23-5
U5, U6: MAX3485; SOP-8_3.9x4.9mm_P1.27mm
U7, U8: TLP2361; SO-6_4.4x3.6mm_P1.27mm
U9, U10: IR2302; SOP-8_3.9x4.9mm_P1.27mm
U11: NJU6319AE; SOP-8_3.9x4.9mm_P1.27mm
Y1: 16MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm_HandSoldering

Connections:
+3.3V: C6.1, C7.1, C11.1, C19.1, C25.1, C26.1, D8.2 (A), D9.1 (K), D15.1 (K), Q15.2 (E), Q16.2 (E), R22.2, R36.2, R47.1, R48.1, R50.1, R52.1, SW1.6, SW1.7, SW1.8, SW1.9, SW1.10, SW2.2 (B), TP4.1, U2.2 (VO), U3.4 (VDD/VDDA), U5.8 (VCC), U6.8 (VCC), U11.1 (~CONT), U11.8 (VDD)
+5V: C4.1, C5.1, C18.1, C23.1, C24.1, D7.2 (A), D8.1 (K), J5.2, Q4.2 (E), Q5.3 (D), R20.2, R33.2, U1.3 (VO), U2.3 (VI), U7.6 (VDD), U8.6 (VDD)
/12VBAT: J1.2, J2.2, Q1.2 (D)
/S-S: C1.1, Q1.3 (S), Q3.3 (S), R7.1, R8.1, SW3.2 (B)
Current_Sence: D15.2 (A), R49.1, U3.11 (PA4), U4.1
DIP_SW0: R1.2, SW1.1, U3.22 (PA11[PA9])
DIP_SW1: R2.2, SW1.2, U3.20 (PC6)
DIP_SW2: R3.2, SW1.3, U3.18 (PA8)
DIP_SW3: R5.2, SW1.4, U3.17 (PB2)
DIP_SW4: R6.2, SW1.5, U3.16 (PB1)
GND: C3.2, C4.2, C5.2, C6.2, C7.2, C10.2, C11.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.1, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, D1.2 (A), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D11.1 (K), D14.1 (K), D21.2 (A), D23.2 (A), J1.1, J2.1, J3.4, J4.1, J5.1, J7.1, J7.2, J8.1, J8.2, J9.1, J9.2, J10.1, J10.2, Q1.1 (G), Q2.2 (S), Q17.2 (S), Q18.2 (S), Q20.1 (S), Q20.2 (S), Q20.3 (S), Q22.1 (S), Q22.2 (S), Q22.3 (S), R1.1, R2.1, R3.1, R4.2, R5.1, R6.1, R7.2, R10.2, R12.2, R17.1, R18.1, R19.1, R20.1, R22.1, R43.1, R44.1, R45.2, R46.2, R49.2, R51.2, R53.2, R54.1, R55.1, R64.1, R66.1, SW4.2 (B), TP5.1, U1.2 (GND), U2.1 (GND), U3.5 (VSS/VSSA), U4.2 (V-), U5.5 (GND), U6.5 (GND), U7.3 (K), U7.4 (GND), U8.3 (K), U8.4 (GND), U9.4 (COM), U10.4 (COM), U11.4 (VSS), Y1.2, Y1.4
LED0: R13.2, U3.29 (PB5)
LED1: R14.2, U3.28 (PB4)
LED2: R15.2, U3.27 (PB3)
MainRX1_RS485aTX: JP1.2 (C), U3.21 (PA10)
MainRX2_RS485bTX: U3.26 (PA15), U5.1 (RO)
MainTX1_RS485aRX: JP2.2 (C), U3.19 (PA9)
MainTX2_RS485bRX: R40.2, U3.9 (PA2), U5.4 (DI)
MonitorLED0: R16.2, U3.31 (PB7)
Motor_A: C29.2, C31.2, D18.1 (K), D19.2 (A), D20.2 (A), D21.1 (K), J6.1, Q19.1 (S), Q19.2 (S), Q19.3 (S), Q20.5 (D), R63.1, U9.6 (VS)
Motor_B: C30.2, D22.2 (A), D23.1 (K), J6.2, Q21.1 (S), Q21.2 (S), Q21.3 (S), Q22.5 (D), R62.1, R65.1, R67.2, U10.6 (VS)
NRST: C10.1, H2.1, J3.6, SW4.1 (A), U3.6 (PF2-NRST)
unnamed: C1.2, Q3.1 (G), R8.2, R9.1
unnamed: C29.1, D16.1 (K), U9.8 (VB)
unnamed: C30.1, D17.1 (K), U10.8 (VB)
unnamed: C31.1, R62.2
unnamed: D3.2 (A), R13.1
unnamed: D4.2 (A), R14.1
unnamed: D5.2 (A), R15.1
unnamed: D6.2 (A), R16.1
unnamed: D11.2 (A), R33.1
unnamed: D14.2 (A), R36.1
unnamed: D18.2 (A), D19.1 (K), R67.1
unnamed: J4.2, Q5.2 (S), Q6.2 (E)
unnamed: JP3.2 (B), R56.1
unnamed: JP4.2 (B), R57.1
unnamed: Q2.3 (D), R9.2
unnamed: Q4.1 (B), Q4.3 (C), Q6.1 (B), R18.2
unnamed: Q5.1 (G), Q6.3 (C), R19.2
unnamed: Q15.1 (B), R40.1
unnamed: Q15.3 (C), R45.1, U5.2 (~RE), U5.3 (DE)
unnamed: Q16.1 (B), R41.1
unnamed: Q16.3 (C), R46.1, U6.2 (~RE), U6.3 (DE)
unnamed: Q17.1 (G), R38.2, R43.2
unnamed: Q17.3 (D), R47.2, U7.1 (A)
unnamed: Q18.1 (G), R39.2, R44.2
unnamed: Q18.3 (D), R48.2, U8.1 (A)
unnamed: Q19.4 (G), R58.2, R63.2
unnamed: Q20.4 (G), R59.2, R64.2
unnamed: Q21.4 (G), R60.2, R65.2
unnamed: Q22.4 (G), R61.2, R66.2
unnamed: R42.1, U4.3 (-)
unnamed: R54.2, U7.5 (VO), U9.2 (IN)
unnamed: R55.2, U8.5 (VO), U10.2 (IN)
unnamed: R58.1, U9.7 (HO)
unnamed: R59.1, U9.5 (LO)
unnamed: R60.1, U10.7 (HO)
unnamed: R61.1, U10.5 (LO)
unnamed: U11.2 (XT), Y1.1
unnamed: U11.3 (~XT), Y1.3
OSC_IN: U3.2 (PC14-OSCX_IN), U11.5 (FOUT)
PWM_A: R38.1, U3.13 (PA6)
PWM_B: R39.1, U3.30 (PB6)
RS485aRX: JP2.1 (A), R41.2, U6.4 (DI)
RS485aTX: JP1.1 (A), U6.1 (RO)
RS485a_A: J9.3, J10.3, JP4.1 (A), R52.2, U6.6 (A)
RS485a_B: J9.4, J10.4, R53.1, R57.2, U6.7 (B)
RS485b_A: J7.3, J8.3, JP3.1 (A), R50.2, U5.6 (A)
RS485b_B: J7.4, J8.4, R51.1, R56.2, U5.7 (B)
SHDN: U3.12 (PA5), U9.3 (~SD), U10.3 (~SD)
STLinkRX: J3.9, JP2.3 (B)
STLinkTX: J3.8, JP1.3 (B)
Sensor0: D9.2 (A), J5.3, U3.15 (PB0)
Slide_SW0: R4.1, SW2.1 (A), U3.8 (PA1)
TCK: J3.3, U3.25 (PA14-BOOT0)
TMS: J3.5, U3.24 (PA13)
VCC: C3.1, C14.1, C15.1, C16.1, C17.1, C22.2, C27.1, C28.1, D2.1 (K), D7.1 (K), D16.2 (A), D17.2 (A), R17.2, U1.1 (VI), U4.5 (V+), U9.1 (VCC), U10.1 (VCC)
VDD: C13.1, D1.1 (K), D2.2 (A), Q3.2 (D), R11.1, R37.2, R42.2, R68.2
V_Measure: R11.2, R12.1, U3.10 (PA3)
Vdrive: C20.1, C21.1, D20.1 (K), D22.1 (K), Q19.5 (D), Q21.5 (D), R37.1, R68.1, U4.4 (+)
主電源スイッチ: Q2.1 (G), R10.1, SW3.1 (A)

Notes on the sheet:
Crystal
MAX3485
Conn to sensor
Conn
スライドスイッチ
5V出力
保護回路・スイッチ
Hブリッジ
Jumper
TestPoint
Conn to Power
STLink
監視LED
Snubber
LED
ハーフブリッジB
5Pスイッチ
I/O
マイコン
RS485a
Conn to Motor
3.3V生成
ハーフブリッジA
5V生成
CurrentSensor
C031K4
NRST
RS485b
インジケーターLED
書き込み
Capacitor
パスコン
PowerModule
主電源スイッチ

Board: 2 copper layers, 110.0 x 60.0 mm, 149 parts (116 on the bottom side), 81 nets.

File LargeMD/jlcpcb/production_files/BOM-LargeMD.csv:

Comment,Designator,Footprint,LCSC
1k,"R13,R14,R15,R16,R33,R36",R_0402_1005Metric,C11702
C,"C29,C30",C_1210_3225Metric_Pad1.33x2.70mm_HandSolder,C13585
16MHz,Y1,Crystal_SMD_3225-4Pin_3.2x2.5mm_HandSoldering,C13738
SSM3J332R,Q5,SOT-23W,C146367
10uF,"C20,C21,C3",C_0805_2012Metric,C15850
1N5819WS,"D1,D15,D7,D8,D9",D_SOD-323_HandSoldering,C191023
3.3k,R49,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C22978
47,"R38,R39,R58,R59,R60,R61",R_0603_1608Metric,C23182
7.5k,"R40,R41",R_0603_1608Metric,C23234
120,"R56,R57",R_0402_1005Metric,C25079
470,"R47,R48",R_0402_1005Metric,C25117
100k,R8,R_0402_1005Metric,C25741
10k,"R1,R10,R17,R18,R19,R2,R20,R22,R3,R4,R43,R44,R5,R54,R55,R6,R63,R64,R65,R66,R67,R7,R9",R_0402_1005Metric,C25744
20k,"R45,R46",R_0402_1005Metric,C25765
10k,R12,R_0603_1608Metric,C25804
2.2k,"R50,R51,R52,R53",R_0402_1005Metric,C25879
S8050,"Q15,Q16,Q4,Q6",SOT-23,C3011093
0.1uF,"C10,C22,C23,C24,C25,C26,C27,C28,C7",C_0402_1005Metric,C307331
33k,R11,R_0603_1608Metric,C4216
BSS138,"Q17,Q18,Q2",SOT-23,C5224274
1uF,"C1,C11,C31,C4,C5,C6",C_0402_1005Metric,C52923
STM32G030K6T6,U3,LQFP-32_7x7mm_P0.8mm,C529331
MAX3485,"U5,U6",SOP-8_3.9x4.9mm_P1.27mm,C558792
MA10EB045,D2,DO-221BC,
SW_SPDT,SW3,3P_SPDT_5Pin_ToggleSwitch,
MountingHole_Pad,H2,TestPoint_Pad_1.5x1.5mm,
Conn_01x04_Male,J10,Molex_SPOX_5267-04A_1x04_P2.50mm_Vertical,
Conn_01x02_Male,J1,AMASS_XT30PW-M_1x02_P2.50mm_Horizontal,
Green,D14,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
470uF,C18,C_Elec_8x10.2,
Conn_01x04_Male,J8,Molex_SPOX_5268-04A_1x04_P2.50mm_Horizontal,
Yellow,D6,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
470uF,C14,C_Elec_8x10.2,
Conn_01x02_Male,J4,Molex_SPOX_5267-02A_1x02_P2.50mm_Vertical,
Conn_01x04_Male,J9,Molex_SPOX_5267-04A_1x04_P2.50mm_Vertical,
SW_SPDT,SW2,3P_SPDT_SlideSwitch,
Conn_01x02_Female,J2,AMASS_XT30PW-F_1x02_P2.50mm_Horizontal,
470uF,C13,C_Elec_8x10.2,
470uF,C16,C_Elec_8x10.2,
Jumper_2_Open,JP4,PinHeader_1x02_P2.54mm_Vertical,
Conn_01x03_Male,J5,Molex_SPOX_5268-03A_1x03_P2.50mm_Horizontal,
Red,D4,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
Conn_01x04_Male,J7,Molex_SPOX_5268-04A_1x04_P2.50mm_Horizontal,
470uF,C19,C_Elec_8x10.2,
Red,D5,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
Red,D3,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
Conn_01x02_Female,J6,AMASS_XT30PW-F_1x02_P2.50mm_Horizontal,
470uF,C17,C_Elec_8x10.2,
Red,D18,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
470uF,C15,C_Elec_8x10.2,
SW_SPST,SW4,SW_SPST_Omron_B3FS-100xP,
LF50_TO220,U1,BP5293,
Red,D19,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
SW_DIP_x05,SW1,DIP-10_W7.62mm,
Green,D11,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
Jumper_2_Open,JP3,PinHeader_1x02_P2.54mm_Vertical,
20mR,R68,R_2512_6332Metric,
SS2040FL,D17,D_SOD-123,
TJ60S04M3L,Q3,TO-252-2,
TestPoint,TP5,TestPoint_THTPad_D2.0mm_Drill1.0mm,
SolderJumper_3_Bridged12,JP2,SolderJumper-3_P2.0mm_Open_TrianglePad1.0x1.5mm_NumberLabels,
LT6106,U4,SOT-23-5,
SS2040FL,D16,D_SOD-123,
20mR,R37,R_2512_6332Metric,
TPH3R704PL,Q20,SOP-Advance,
TLP2361,U7,SO-6_4.4x3.6mm_P1.27mm,
AZ1084CD-3.3,U2,TO-252-3_TabPin2,
TLP2361,U8,SO-6_4.4x3.6mm_P1.27mm,
SolderJumper_3_Bridged12,JP1,SolderJumper-3_P2.0mm_Open_TrianglePad1.0x1.5mm_NumberLabels,
SS2040FL,D23,D_SOD-123,
TJ60S04M3L,Q1,TO-252-2,
TPH3R704PL,Q21,SOP-Advance,
SS2040FL,D21,D_SOD-123,
IR2302,U9,SOP-8_3.9x4.9mm_P1.27mm,
IR2302,U10,SOP-8_3.9x4.9mm_P1.27mm,
SS2040FL,D20,D_SOD-123,
39,R42,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
Conn_01x10_Male,J3,BoxHeader_2x05_P1.27mm_Horizontal,
TPH3R704PL,Q19,SOP-Advance,
MPR,R62,R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal,
SS2040FL,D22,D_SOD-123,
NJU6319AE,U11,SOP-8_3.9x4.9mm_P1.27mm,
TPH3R704PL,Q22,SOP-Advance,
TestPoint,TP4,TestPoint_THTPad_D2.0mm_Drill1.0mm,

## Commit log

2024-01-30 回路設計
2024-01-30 MV2_EncoderのDXFデータ追加
2024-01-30 IR基板のエッジとシルク追加
2024-01-30 MV2_MDのDXFデータ
2024-01-30 IR基板のEdgeCuts修正
2024-01-30 MV2_MDのDXFデータ修正
2024-02-01 構成図追加
2024-02-01 MV2 PWのDXFde-ta
2024-02-01 SmallMDの基板外形追加
2024-02-01 diagram_SmallPW
2024-02-01 diagram
2024-02-01 回路図pdf出力
2024-02-01 SmallMDの裏面実装禁止エリア追加
2024-02-01 SmallPW基板外形追加
2024-02-01 定期更新
2024-02-02 MV2 PWの入れ替え
2024-02-02 MV2 PanelのDXFデータ
2024-02-03 IR基板外形の修正
2024-02-04 IR、SmallMD、SmallPWのdxf追加
2024-02-04 エンコーダー基板配線完了
2024-02-05 LargeMD
2024-02-06 Mother外形追加
2024-02-06 人力曲面配線中
2024-02-06 ゴリ押し人力配線
2024-02-07 基板類の外形にフィレットをかけた
2024-02-07 IR半分
2024-02-07 IR基板のシルクスクリーン変更
2024-02-07 LargeMDほぼ完成
2024-02-07 SmallMDほぼ完成
2024-02-10 製造ファイル出力
2024-02-10 製造ファイル出力その2
2024-02-10 アームLED基板とアーム接続基板追加
2024-02-10 回路図プロット
2024-02-13 DCDC回路図変更
2024-02-16 MV2_PW
2024-02-17 回路図ほぼ完成
2024-02-20 Pole,Panelほぼ完成
2024-02-26 Mother_Ctrl回路図プロット
2024-02-27 回路図確定
2024-02-28 多分完成
2024-03-16 pole
2024-03-25 全国大会終わり
2024-04-02 パネルPDF更新
2024-04-02 DCDC全国仕様書き起こし
2024-11-15 gitignore追加
