# Repository Tomoshibi-technology/RCJ-Japan2024-Circuit (continued)

## KiCad design Mother_Ctrl/Mother_Ctrl.kicad_pcb (continued)

Board: 2 copper layers, 100.0 x 60.0 mm, 253 parts (201 on the bottom side), 157 nets.

File Mother_Ctrl/jlcpcb/production_files/BOM-Mother_Ctrl.csv:

Comment,Designator,Footprint,LCSC
1k,"R11,R15,R17,R18,R19,R22,R26,R36,R62,R63,R66,R67,R70,R71,R72,R73",R_0402_1005Metric,C11702
16MHz,Y1,Crystal_SMD_3225-4Pin_3.2x2.5mm_HandSoldering,C13738
SSM3J332R,"Q10,Q13,Q15,Q17,Q19,Q21,Q4,Q6,Q9",SOT-23W,C146367
ADJ_ST,"C12,C8",C_0603_1608Metric,C14663
0.1uF,"C2,C24,C25,C26,C27,C28,C29,C32,C33,C34,C35,C36,C37,C4,C5,C6",C_0402_1005Metric,C1525
10uF,C3,C_0805_2012Metric,C15850
22pF,"C15,C16,C17,C18",C_0603_1608Metric,C1653
1N5819WS,"D1,D10,D11,D12,D13,D14,D15,D16,D17,D18,D19,D2,D20,D31,D32,D33,D34,D35,D36,D37,D38,D39,D5",D_SOD-323_HandSoldering,C191023
4.7uF,C30,C_0603_1608Metric,C19666
7.5k,"R88,R89,R92",R_0603_1608Metric,C23234
10,R24,R_0402_1005Metric,C25077
120,"R98,R99",R_0402_1005Metric,C25079
330,R23,R_0402_1005Metric,C25104
100k,"R2,R21,R29,R37,R60",R_0402_1005Metric,C25741
10k,"R1,R102,R103,R12,R13,R14,R16,R20,R25,R27,R28,R30,R31,R32,R33,R34,R35,R38,R39,R4,R40,R41,R42,R43,R44,R45,R46,R47,R48,R49,R50,R51,R52,R53,R54,R55,R56,R57,R58,R59,R61,R65,R68,R69,R74,R75,R76,R77,R78,R79,R80,R81,R82,R83,R86,R87,R9",R_0402_1005Metric,C25744
20k,"R90,R91,R93",R_0402_1005Metric,C25765
10k,"R8,R84,R85",R_0603_1608Metric,C25804
2.2k,"R100,R101,R94,R95,R96,R97",R_0402_1005Metric,C25879
5.1k,"R10,R6",R_0402_1005Metric,C25905
S8050,"Q11,Q12,Q14,Q16,Q18,Q20,Q22,Q30,Q31,Q32,Q5,Q7,Q8",SOT-23,C3011093
33k,R7,R_0603_1608Metric,C4216
BSS138,"Q2,Q23,Q24,Q25,Q26,Q27,Q28",SOT-23,C5224274
1uF,"C1,C11,C13,C14,C19,C31,C9",C_0402_1005Metric,C52923
MAX3485,"U6,U7,U8",SOP-8_3.9x4.9mm_P1.27mm,C558792
STM32F446RETx,U4,LQFP-64_10x10mm_P0.5mm,C69336
USB_C_Receptacle_USB2.0,J3,USB_C_Receptacle_G-Switch_GT-USB-7010ASV,C963412
CH340E,U1,MSOP-10_3x3mm_P0.5mm,C99652
Yellow,D26,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
Conn_01x10_Male,J5,BoxHeader_2x05_P1.27mm_Vertical_SMD,
Red,D6,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
Conn_01x04_Male,J10,Molex_SPOX_5268-04A_1x04_P2.50mm_Horizontal,
Conn_01x12_Female,J16,PinSocket_1x12_P2.54mm_Vertical,
Green,D29,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
Conn_01x02_Male,J6,Molex_SPOX_5268-02A_1x02_P2.50mm_Horizontal,
Conn_01x02_Female,J2,AMASS_XT30PW-F_1x02_P2.50mm_Horizontal,
Conn_01x04_Male,J12,Molex_SPOX_5268-04A_1x04_P2.50mm_Horizontal,
470uF,C21,C_Elec_8x10.2,
Red,D7,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
SW_DPDT_x2,SW4,SW_CuK_JS202011CQN_DPDT_Straight,
Yellow,D3,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
Red,D23,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
Jumper_2_Open,JP1,PinHeader_1x02_P2.54mm_Vertical,
Conn_01x05_Male,J14,Molex_SPOX_5268-05A_1x05_P2.50mm_Horizontal,
Red,D8,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
SW_SPST,SW2,SW_Push_1P1T_NO_Vertical_Wuerth_434133025816,
Yellow,D25,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
Conn_01x03_Male,J7,Molex_SPOX_5268-03A_1x03_P2.50mm_Horizontal,
Conn_01x12_Female,J15,PinSocket_1x12_P2.54mm_Vertical,
PullUP?,R64,R_0603_1608Metric,
470uF,C20,C_Elec_8x10.2,
MA10EB045,D4,DO-221BC,
Conn_01x02_Male,J1,AMASS_XT30PW-M_1x02_P2.50mm_Horizontal,
Green,D27,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
Jumper_2_Open,JP2,PinHeader_1x02_P2.54mm_Vertical,
10uF,C10,C_0805_2012Metric,
22uF,C7,C_0805_2012Metric,
Green,D28,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
SW_SPST,SW6,SW_Push_1P1T_NO_Vertical_Wuerth_434133025816,
470uF,C23,C_Elec_8x10.2,
Conn_01x04_Male,J11,Molex_SPOX_5268-04A_1x04_P2.50mm_Horizontal,
MTP4835I3,Q1,TO-252-2,
SW_SPDT,SW5,3P_SPDT_SlideSwitch,
OKL-T/6-W12N-C,MD1,MURATA_OKL-T-6-W12N-C,
SW_SPST,SW7,SW_Push_1P1T_NO_Vertical_Wuerth_434133025816,
SW_SPST,SW3,SW_Push_1P1T_NO_Vertical_Wuerth_434133025816,
Conn_01x03_Male,J8,Molex_SPOX_5268-03A_1x03_P2.50mm_Horizontal,
Conn_01x05_Male,J13,Molex_SPOX_5268-05A_1x05_P2.50mm_Horizontal,
MTP4835I3,Q3,TO-252-2,
Conn_01x04_Male,J9,Molex_SPOX_5268-04A_1x04_P2.50mm_Horizontal,
TWE-L-WX,U2,MonoWireless_TWE-L-WX,
470uF,C22,C_Elec_8x10.2,
Conn_01x12_Female,J17,PinSocket_1x12_P2.54mm_Vertical,
Conn_01x07_Female,J4,PinSocket_1x07_P2.54mm_Horizontal,
BNO055,U5,BNO055,
MTP4835I3,Q29,TO-252-2,
SW_SPDT,SW1,3P_SPDT_5Pin_ToggleSwitch,
TestPoint,TP5,TestPoint_THTPad_D2.0mm_Drill1.0mm,
Green,D30,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
Red,D22,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
32.768kHz,Y2,Crystal_SMD_3215-2Pin_3.2x1.5mm,
PullUP?,R3,R_0603_1608Metric,
MountingHole_Pad,H5,TestPoint_Pad_1.0x1.0mm,
MountingHole_Pad,H4,TestPoint_Pad_1.0x1.0mm,
MountingHole_Pad,H7,TestPoint_Pad_1.5x1.5mm,
MountingHole_Pad,H11,TestPoint_Pad_1.5x1.5mm,
MountingHole_Pad,H8,TestPoint_Pad_1.5x1.5mm,
AZ1084CD-3.3,U3,TO-252-2,
PullUP?,R5,R_0603_1608Metric,
D_Zener,D9,D_SOD-323_HandSoldering,
D_Zener,D21,D_SOD-323_HandSoldering,

## KiCad design LargePW/LargePW.kicad_pcb

Parts:
C1: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2: 10000uF; CP_Radial_D35.0mm_P10.00mm_SnapIn
D1, D2: CUS10F30; D_SOD-323_HandSoldering
F1: Fuse; Fuseholder_Blade_Mini_Keystone_3568
H1, H2: MountingHole_Pad; TestPoint_THTPad_D4.0mm_Drill2.0mm
J1: Conn_01x02_Female; Molex_SPOX_5267-02A_1x02_P2.50mm_Vertical
J2, J3, J4, J5, J6, J7, J8, J9, J10, J11, J12, J13: Conn_01x02_Female; AMASS_XT30U-F_1x02_P5.0mm_Vertical
K1: RAYEX-L90; TRV4-L-12V-Z-F
MES1: Voltmeter_DC; SuperSmallVoltmeter_twoline
Q1, Q2, Q3, Q4: TJ60S04M3L; TO-252-2
Q5, Q6: BSS138; SOT-23_Handsoldering
R1, R5, R6: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R4: 510; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_SPST; DS-850K-S-ON

Connections:
+12V: F1.1, H2.1
/RelayIN: F1.2, J1.1, K1.30, SW1.2 (B)
/RelayOUT: K1.87, Q1.2 (D), Q2.2 (D)
/S-S: C1.1, Q1.3 (S), Q2.3 (S), Q3.3 (S), Q4.3 (S), R1.2, R2.1
ESS: D1.1 (K), J1.2, K1.85
GND: C2.2, D2.2 (A), H1.1, J2.1, J3.1, J4.1, J5.1, J6.1, J7.1, J8.1, J9.1, J10.1, J11.1, J12.1, J13.1, MES1.1 (-), Q1.1 (G), Q2.1 (G), Q5.2 (S), Q6.2 (S), R1.1, R6.1, R7.2
unnamed: Q3.1 (G), R3.1
unnamed: Q4.1 (G), R4.2
unnamed: Q5.1 (G), Q6.1 (G), R6.2, SW1.1 (A)
unnamed: Q5.3 (D), R5.1
RelaySW: D1.2 (A), K1.86, Q6.3 (D)
VDD: C2.1, D2.1 (K), J2.2, J3.2, J4.2, J5.2, J6.2, J7.2, J8.2, J9.2, J10.2, J11.2, J12.2, J13.2, MES1.2 (+), Q3.2 (D), Q4.2 (D), R7.1
主電源スイッチ: C1.2, R2.2, R3.2, R4.1, R5.2

Notes on the sheet:
Conn to Battery
保護回路・スイッチ
Conn to CircuitBoard
主電源スイッチ
Fuse
Relay
非常停止スイッチ

Board: 2 copper layers, 86.0 x 100.0 mm, 36 parts (11 on the bottom side), 13 nets.

File LargePW/jlcpcb/production_files/BOM-LargePW.csv:

Comment,Designator,Footprint,LCSC
1k,R7,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
RAYEX-L90,K1,TRV4-L-12V-Z-F,
Conn_01x02_Female,J2,AMASS_XT30U-F_1x02_P5.0mm_Vertical,
Conn_01x02_Female,J12,AMASS_XT30U-F_1x02_P5.0mm_Vertical,
Conn_01x02_Female,J3,AMASS_XT30U-F_1x02_P5.0mm_Vertical,
Conn_01x02_Female,J6,AMASS_XT30U-F_1x02_P5.0mm_Vertical,
Conn_01x02_Female,J1,Molex_SPOX_5267-02A_1x02_P2.50mm_Vertical,
Conn_01x02_Female,J9,AMASS_XT30U-F_1x02_P5.0mm_Vertical,
Conn_01x02_Female,J7,AMASS_XT30U-F_1x02_P5.0mm_Vertical,
Conn_01x02_Female,J4,AMASS_XT30U-F_1x02_P5.0mm_Vertical,
Fuse,F1,Fuseholder_Blade_Mini_Keystone_3568,
Conn_01x02_Female,J10,AMASS_XT30U-F_1x02_P5.0mm_Vertical,
Conn_01x02_Female,J11,AMASS_XT30U-F_1x02_P5.0mm_Vertical,
Conn_01x02_Female,J5,AMASS_XT30U-F_1x02_P5.0mm_Vertical,
TJ60S04M3L,Q1,TO-252-2,
Conn_01x02_Female,J13,AMASS_XT30U-F_1x02_P5.0mm_Vertical,
SW_SPST,SW1,DS-850K-S-ON,
MountingHole_Pad,H1,TestPoint_THTPad_D4.0mm_Drill2.0mm,
TJ60S04M3L,Q4,TO-252-2,
Conn_01x02_Female,J8,AMASS_XT30U-F_1x02_P5.0mm_Vertical,
Voltmeter_DC,MES1,SuperSmallVoltmeter_twoline,
MountingHole_Pad,H2,TestPoint_THTPad_D4.0mm_Drill2.0mm,
TJ60S04M3L,Q2,TO-252-2,
TJ60S04M3L,Q3,TO-252-2,
10000uF,C2,CP_Radial_D35.0mm_P10.00mm_SnapIn,
BSS138,Q5,SOT-23_Handsoldering,
CUS10F30,D2,D_SOD-323_HandSoldering,
10k,R6,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
510,R4,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
10k,R5,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
BSS138,Q6,SOT-23_Handsoldering,
100k,R2,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
1uF,C1,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,
510,R3,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
10k,R1,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
CUS10F30,D1,D_SOD-323_HandSoldering,
